# Repository psas/tsar-hardware (continued)

## EAGLE design valve_indicator/Schematics/valve_indicator.brd (continued)

Parts:
C1: 4.7nF; C0603; MPN C1608C0G1H472J080AA
C2, C3, C4, C5, C6, C7, C8, C9: 4.7nF; C0603K; MPN C1608C0G1H472J080AA
HES1: HES1; 1X03; MPN 1718570003
HES2: HES2; 1X03; MPN 1718570003
HES3: HES3; 1X03; MPN 1718570003
HES4: HES4; 1X03; MPN 1718570003
HES5: HES5; 1X03; MPN 1718570003
HES6: HES6; 1X03; MPN 1718570003
HES7: HES7; 1X03; MPN 1718570003
HES8: HES8; 1X03; MPN 1718570003
HES9: HES9; 1X03; MPN 1718570003
JP1: PINHD-2X5; 2X05; MPN AWHW 10A-0202-T
JP3: PINHD-1X12; 1X12; MPN 1718570012
Q1, Q2, Q3, Q4, Q6: PMV45EN2R; SOT23; MPN PMV45EN2R
R1, R2, R3, R4, R5, R6, R7, R8, R9, R14, R15, R16, R17, R18, R20: 10k; .0603-C-NOSILK; MPN RMCF0603FT10K0
R10, R11, R12, R13: 1k; .0603-C-NOSILK; MPN RMCF0603JJ1K00
R21: 1k; R0603; MPN RMCF0603JJ1K00
SM_STAT: SM_STAT; 1X05; MPN AWHW 10A-0202-T

Connections:
+3V3: R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1; also elsewhere on the board
+10V: HES1.1, HES2.1, HES3.1, HES4.1, HES5.1, HES6.1, HES7.1, HES8.1, HES9.1, JP1.2, JP1.4, JP1.6, JP1.8, JP1.10; also elsewhere on the board
BUZZ: JP1.1, R13.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, HES1.2, HES2.2, HES3.2, HES4.2, HES5.2, HES6.2, HES7.2, HES8.2, HES9.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q6.2 (S), R15.1, R16.1, R17.1, R18.1, R20.1, SM_STAT.3; also elsewhere on the board
IN_CTS: SM_STAT.4; also elsewhere on the board
IN_H1: C1.1, HES1.3, JP3.1, R1.2; also elsewhere on the board
IN_H2: C2.1, HES2.3, JP3.2, R2.2; also elsewhere on the board
IN_H3: C3.1, HES3.3, JP3.3, R3.2; also elsewhere on the board
IN_H4: C4.1, HES4.3, JP3.4, R4.2; also elsewhere on the board
IN_H5: C5.1, HES5.3, JP3.5, R5.2; also elsewhere on the board
IN_H6: C6.1, HES6.3, JP3.6, R6.2; also elsewhere on the board
IN_H7: C7.1, HES7.3, JP3.7, R7.2; also elsewhere on the board
IN_H8: C8.1, HES8.3, JP3.8, R8.2; also elsewhere on the board
IN_H9: C9.1, HES9.3, JP3.9, R9.2; also elsewhere on the board
IN_RTS: SM_STAT.5; also elsewhere on the board
IN_UART-RX: R14.2; also elsewhere on the board
IN_UART-TX: SM_STAT.1; also elsewhere on the board
LED0: JP1.9, R21.2
LED1: JP1.7, R10.2
LED2: JP1.5, R11.2
LED3: JP1.3, R12.2
unnamed: Q4.3 (D), R13.1
unnamed: Q6.3 (D), R21.1
unnamed: Q3.3 (D), R12.1
unnamed: Q1.3 (D), R10.1
unnamed: Q2.3 (D), R11.1
OUT_BUZZ: Q4.1 (G), R18.2; also elsewhere on the board
OUT_LED0: Q6.1 (G), R20.2; also elsewhere on the board
OUT_LED1: Q1.1 (G), R15.2; also elsewhere on the board
OUT_LED2: Q2.1 (G), R16.2; also elsewhere on the board
OUT_LED3: Q3.1 (G), R17.2; also elsewhere on the board
UART_RX: R14.1, SM_STAT.2

Notes on the sheet:
State Machine Status Input From UART on AC Board CTS/RTS added to sync up clocks
Data Inputs, -9 Hall Effect Sensors -State Machine Status
Indication Outputs, -3 LED arrays -1 Buzzer -SD Card Data Backup

Board: 2 copper layers, 93.3 x 95.1 mm, 131 parts (0 on the bottom side), 84 nets.

File valve_indicator/BOM.csv:

"Qty";"Value";"Device";"Package";"Parts";"Description";"DESCRIPTION";"DIS";"DPN";"HEIGHT";"MANUFACTURER_NAME";"MANUFACTURER_PART_NUMBER";"MFR";"MOUSER_PART_NUMBER";"MOUSER_PRICE-STOCK";"MPN";"POPULARITY";"RS_PART_NUMBER";"RS_PRICE-STOCK";"SPICEPREFIX";
"2";".33";"R-US_R0603";"R0603";"RS_H, RS_L";"RESISTOR, American symbol";"";"Digi-Key";"P.33AJCT-ND";"";"";"";"Panasonic Electronic Components";"";"";"ERJ-3RQFR33V";"77";"";"";"R";
"3";"100nF";"C-USC0603";"C0603";"C10, C11, C12";"CAPACITOR, American symbol";"";"Digi-Key";"1276-1006-1-ND";"";"";"";" Samsung Electro-Mechanics";"";"";"CL10B104KA8NNNC";"37";"";"";"C";
"2";"100uF";"C-US025-025X050";"C025-025X050";"C1_H, C1_L";"CAPACITOR, American symbol";"";"Digi-Key";"1572-1044-ND";"";"";"";"Illinois Capacitor";"";"";"107CKR050M";"0";"";"";"C";
"14";"10k";"R-US_R0603";"R0603";"R1, R2, R3, R4, R5, R6, R7, R8, R9, R14, R15, R16, R17, R18";"RESISTOR, American symbol";"";"Digi-Key";"RMCF0603FT10K0CT-ND";"";"";"";"Stackpole Electronics Inc";"";"";"RMCF0603FT10K0";"77";"";"";"R";
"2";"10uF";"C-USC1206";"C1206";"C0_H, C0_L";"CAPACITOR, American symbol";"";"Digi-Key";"1276-6736-1-ND";"";"";"";"Samsung Electro-Mechanics";"";"";"CL31A106MBHNNNE";"24";"";"";"C";
"2";"1N5819G_0_0";"ON_SEMICONDUCTOR_1N5819GON_SEMICONDUCTOR_1N5819G_0_0";"ON_SEMICONDUCTOR_1N5819G_0";"D1, D2";"ONSC-D-K1A2-2_A";"";"Digi-Key";"1N5819GOS-ND";"";"";"";"On Semiconductor";"";"";"1N5819G";"";"";"";"";
"4";"1k";"R-US_R0603";"R0603";"R10, R11, R12, R13";"RESISTOR, American symbol";"";"Digi-Key";"RMCF0603JJ1K00CT-ND";"";"";"";"Stackpole Electronics Inc";"";"";"RMCF0603JJ1K00";"77";"";"";"R";
"1";"2.2k";"R-US_R0603";"R0603";"R2_L";"RESISTOR, American symbol";"";"Digi-Key";"P2.20KHCT-ND";"";"";"";"Panasonic Electronic Components";"";"";"ERJ-3EKF2201V";"77";"";"";"R";
"1";"220uH";"L-US0204/5";"0204/5";"L2";"INDUCTOR, American symbol";"";"Digi-Key";"811-2101-ND ";"";"";"";"Murata Power Solutions Inc. ";"";"";"12RS224C";"0";"";"";"L";
"1";"220uH";"L-US0204/5";"0204/5";"L1";"INDUCTOR, American symbol";"";"DigiKey";"811-2101-ND ";"";"";"";"Murata Power Solutions Inc. ";"";"";"12RS224C";"0";"";"";"L";
"1";"24V";"DCBARRELSMT";"DCJACK_2MM_SMT";"POE_IN";"2.0mm DC Barrel Jack";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"3.3k";"R-US_R0603";"R0603";"R1_H";"RESISTOR, American symbol";"";"Digi-Key";"311-3.30KHRCT-ND";"";"";"";"Yageo";"";"";"RC0603FR-073K3L";"77";"";"";"R";
"1";"3.6k";"R-US_R0603";"R0603";"R1_L";"RESISTOR, American symbol";"";"Digi-Key";"311-3.60KHRCT-ND";"";"";"";"Yageo";"";"";"RC0603FR-073K6L";"77";"";"";"R";
"9";"4.7nF";"C-USC0603";"C0603";"C1, C2, C3, C4, C5, C6, C7, C8, C9";"CAPACITOR, American symbol";"";"Digi-Key";"445-7400-1-ND";"";"";"";"TDK Corporation";"";"";"C1608C0G1H472J080AA";"37";"";"";"C";
"1";"470";"R-US_R0603";"R0603";"R2_H";"RESISTOR, American symbol";"";"Digi-Key";"A129684CT-ND";"";"";"";"TE Connectivity Passive Product";"";"";"CRGCQ0603F470R";"77";"";"";"R";
"2";"470pF";"C-USC0603";"C0603";"C2_H, C2_L";"CAPACITOR, American symbol";"";"Digi-Key";"1292-1438-1-ND";"";"";"";"Walsin Technology Corporation";"";"";"0603B471K500CT";"37";"";"";"C";
"2";"470uF";"C-USC0603";"C0603";"C3_H, C3_L";"CAPACITOR, American symbol";"";"Digi-Key";"399-15683-ND";"";"";"";"KEMET";"";"";"ESH477M050AH4AA";"37";"";"";"C";
"2";"AZ34063UMTR-G1";"DIODES_INC._AZ34063UMTR-G1DIODES_INC._AZ34063UMTR-G1_0_0";"DIODES_INC._AZ34063UMTR-G1_0";"U1, U2";"Buck, Boost Switching Regulator IC Positive or Negative Adjustable 1.25V 1 Output 1.5A (Switch) 8-SOIC (0.154", 3.90mm Width)";"";"Digi-Key";"AZ34063UMTR-G1DICT-ND";"";"";"";"Diodes Incorporated";"";"";"AZ34063UMTR-G1";"";"";"";"";
"1";"FTSH-105-XX-X-DV-K";"FTSH-105-XX-X-DV-K";"CON10_2X5_DUK_FTSH";"CM1";"";"";"Digi-Key";"SAM13160CT-ND";"";"";"";"Samtec Inc.";"";"";"FTSH-105-01-F-DV-K-TR";"";"";"";"";
"1";"HES1";"PINHD-1X3";"1X03";"HES1";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES2";"PINHD-1X3";"1X03";"HES2";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES3";"PINHD-1X3";"1X03";"HES3";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES4";"PINHD-1X3";"1X03";"HES4";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES5";"PINHD-1X3";"1X03";"HES5";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES6";"PINHD-1X3";"1X03";"HES6";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES7";"PINHD-1X3";"1X03";"HES7";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES8";"PINHD-1X3";"1X03";"HES8";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"HES9";"PINHD-1X3";"1X03";"HES9";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"LED1";"PINHD-1X2";"1X02";"BATT";"PIN HEADER";"";"Digi-Key";"900-0022232021-ND";"";"";"";"Molex";"";"";"0022232021";"98";"";"";"";
"1";"LEDS";"PINHD-2X4";"2X04";"JP1";"PIN HEADER";"";"";"";"";"";"";"";"";"";"";"47";"";"";"";
"4";"MOUNT-HOLE2.8";"MOUNT-HOLE2.8";"2,8";"H1, H2, H3, H5";"MOUNTING HOLE with drill center marker";"";"";"";"";"";"";"";"";"";"";"15";"";"";"";
"4";"PMV45EN2R";"PMV45EN2R";"SOT23";"Q1, Q2, Q3, Q4";"Nexperia PMV45EN2R N-channel MOSFET, 5.1 A, 30 V PMV45EN2, 3-Pin SOT-23";"Nexperia PMV45EN2R N-channel MOSFET, 5.1 A, 30 V PMV45EN2, 3-Pin SOT-23";"Digi-Key";"1727-2307-1-ND";"1.1mm";"Nexperia";"PMV45EN2R";"Nexperia USA Inc.";"771-PMV45EN2R";"https://www.mouser.com/Search/Refine.aspx?Keyword=771-PMV45EN2R";"PMV45EN2R";"";"1364835P";"http://uk.rs-online.com/web/p/products/1364835P";"";
"1";"SB240";"1N5817-B";"DO41-7.6";"D3";"1.0A SCHOTTKY BARRIER RECTIFIER";"";"Digi-Key";"SB240-E3/54GICT-ND";"";"";"";"Vishay Semiconductor Diodes Division";"";"";"SB240-E3/54";"0";"";"";"";
"1";"SD";"PINHD-1X6";"1X06";"SD_CARD";"PIN HEADER";"";"Digi-Key";"A33867-ND";"";"";"";"TE Connectivity AMP Connectors";"";"";"5-103635-5";"79";"";"";"";
"1";"SM_STAT";"PINHD-1X3";"1X03";"SM_STAT";"PIN HEADER";"";"Digi-Key";"WM2701-ND";"";"";"";"Molex";"";"";"0022112032";"92";"";"";"";
"1";"STM32F042K6";"STM32F042K6";"QFP32-7X7";"U3";"";"";"Digi-Key";"497-14647-ND";"";"";"";"STMicroelectronics";"";"";"STM32F042K6T6";"";"";"";"";
"9";"TEST-POINT-LARGE-SQUARE";"TEST-POINT-LARGE-SQUARE";"1X01";"TP3V3, TP3V3J, TP10V, TPBASE, TPJGND, TPNRST, TPOE, TPSCLK, TPSIO";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";

## EAGLE design tsar_SensorFrontEnd/tsar_SensorFrontEnd.brd

File tsar_SensorFrontEnd/readme.md:

This folder contains the Eagle files for the Sensor Front-End board to interface sensors with the marionette

Parts:
3V3., 5V., 12V.: Green; CHIP-LED0603; MPN 5988070107F
C24, C27, C46: 0.1uF; C0603K; MPN CL10B104KB8NNNL
C25, C52, C53: 10uF; C1206K; MPN CL31A106MBHNNNE
C26, C45: 4.7uF; C0805K; MPN CL21A475KBQNNNE
C43: 100nF; C0603K; MPN CL10B104KB8NNNL
C47, C49: 47pF; C0603K; MPN C1608C0G1H470J080AA
C50, C51: 1uF; C0603K; MPN CL10A105KB8NNNC
D27, D31: DFLS160; POWERDI-123; MPN DFLS160-7
D30: 1N4148W-7-F; SOD123; MPN 1N4148W-7-F
H3, H4, H5, H6: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER
L1: CLF5030NIT-100M-D; 0.209"LX0.197"W(5.30MMX5.00MM); MPN CLF5030NIT-100M-D
L3: 33uH; 0.209"LX0.197"W(5.30MMX5.00MM); MPN PM4340.333NLT
POE: 22-23-2021
POE+.: Green; CHIP-LED0603; MPN 5988070107F
POE_BYPASS: 100u; C2.5-4; MPN ECA-1HM101
POE_IN_5V: PINHD-1X2; 1X02; MPN 0022232021
R35: 73.2k; .0805-A-NOSILK; MPN RK73H2ATTD7322F
R36: 23.7k; .0805-A-NOSILK; MPN RK73H2ATTD2372F
R37: 10k; .0805-B; MPN ESR03EZPF1002
R38: NP; R0603
R45, R85: 20k; .0603-A-NOSILK; MPN ERJ-PA3J203V
R46, R84: 1k; .0603-A-NOSILK; MPN ERJ-PA3F1001V
R69: 113k; .0805-A-NOSILK; MPN RK73H2ATTD1133F
R75: 8.2k; .0805-A-NOSILK; MPN RK73H2ATTD8201F
R76: 500k; 1206-A; MPN CRMA1206AF500KFKEF
R77: NP; .0805-A-NOSILK
R80, R81, R82, R83: 0; .0603-A-NOSILK; MPN RCS06030000Z0EA
THRUSTPOWER: 22-23-2021
U$2, U$4: MP2456GJ-P; SOT6; MPN MP2456GJ-P

Connections:
+3V3: C25.1, D30.2, L1.2, R35.2, R82.2, R84.2; also elsewhere on the board
+5V: POE_IN_5V.1, R46.2; also elsewhere on the board
+12V: C50.1, C51.1, C52.1, C53.1, L3.2, R45.1, R69.2, R80.2, THRUSTPOWER.1; also elsewhere on the board
+24V: C26.1, C27.1, C45.1, C46.1, POE.1, POE_BYPASS.1, R37.2, R76.2, R85.1, U$2.P$5 (IN), U$4.P$5 (IN)
FLY1: C24.2, D27.C, L1.1, U$4.P$6 (SW)
FLY3: C43.2, D31.C, L3.1, U$2.P$6 (SW)
GND: 3V3..C, 5V..C, 12V..C, C25.2, C26.2, C27.2, C45.2, C46.2, C50.2, C51.2, C52.2, C53.2, D27.A, D31.A, POE.2, POE+..C, POE_BYPASS.2, POE_IN_5V.2, R36.1, R38.1, R75.1, R77.1, THRUSTPOWER.2, U$2.P$2 (GND), U$4.P$2 (GND); also elsewhere on the board
unnamed: C24.1, R83.1
unnamed: D30.1, R83.2, U$4.P$1 (BST)
unnamed: R37.1, R38.2, U$4.P$4 (EN)
unnamed: C43.1, R81.2
unnamed: C47.2, R69.1, R75.2, U$2.P$3 (FB)
unnamed: R76.1, R77.2, U$2.P$4 (EN)
unnamed: C47.1, R80.1
unnamed: R81.1, U$2.P$1 (BST)
unnamed: C49.2, R35.1, R36.2, U$4.P$3 (FB)
unnamed: C49.1, R82.1
unnamed: 3V3..A, R84.1
unnamed: 5V..A, R46.1
unnamed: 12V..A, R45.2
unnamed: POE+..A, R85.2

Notes on the sheet:
24V input, 3V3 output voltage regulator (for ADS8344 output logic level)
ALL RESISTORS ARE 0603 1% UNLESS OTHERWISE MARKED
ALL CAPACITORS ARE 0805 10% X5R WITH WORKING VOLTAGE > 50V UNLESS OTHERWISE MARKED
+24V input from POE 24V @ < 3000mA
Electrolytic Cap
24V input, 12V output voltage regulator (for Pressure Sensors)
5V input from POE+ Input Board; up to 3A (for AD58344 & Thermocouple Sensors)
To Thrust Plate Amp Board

Parts:
ANALOG_TO_DAQ: IDC_RECEPTACLE_2X20-S9175-ND; IDC_RECEPTACLES; MPN SBH11-PBPC-D20-ST-BK
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10: 120pF; C0603K; MPN CL10C121JB8NNNC
D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: D5V0H1U2LP1610-7; 0603DIODE; MPN D5V0H1U2LP1610-7
PT-F01, PT-F02, PT-F03, PT-F04: 22-23-2021
PT-L01, PT-L02, PT-L03, PT-L04: 22-23-2021
PT-M01, PT-M02: 22-23-2021
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: 150; .0805-A-NOSILK; MPN 4-2176091-1
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 1k; .0603-A-NOSILK; MPN ERJ-PA3F1001V
TP: 22-23-2051

Connections:
+12V: PT-F01.1, PT-F02.1, PT-F03.1, PT-F04.1, PT-L01.1, PT-L02.1, PT-L03.1, PT-L04.1, PT-M01.1, PT-M02.1; also elsewhere on the board
ADC0.0: ANALOG_TO_DAQ.15, TP.4
ADC0.1: ANALOG_TO_DAQ.17, TP.3
ADC0.2: ANALOG_TO_DAQ.19, TP.2
ADC0.3: ANALOG_TO_DAQ.21, TP.1
ADC0.4: ANALOG_TO_DAQ.23, C10.1, D17.P$2, R20.1
ADC0.5: ANALOG_TO_DAQ.25, C9.1, D16.P$2, R19.1
ADC0.6: ANALOG_TO_DAQ.27, C8.1, D15.P$2, R18.1
ADC1.0: ANALOG_TO_DAQ.16, C1.1, D8.P$2, R11.1
ADC1.1: ANALOG_TO_DAQ.18, C2.1, D9.P$2, R12.1
ADC1.2: ANALOG_TO_DAQ.20, C3.1, D10.P$2, R13.1
ADC1.3: ANALOG_TO_DAQ.22, C4.1, D11.P$2, R14.1
ADC1.4: ANALOG_TO_DAQ.24, C5.1, D12.P$2, R15.1
ADC1.5: ANALOG_TO_DAQ.26, C6.1, D13.P$2, R16.1
ADC1.6: ANALOG_TO_DAQ.28, C7.1, D14.P$2, R17.1
DAC0: ANALOG_TO_DAQ.7
DAC1: ANALOG_TO_DAQ.8
DAC2: ANALOG_TO_DAQ.9
DAC3: ANALOG_TO_DAQ.10
DIO62: ANALOG_TO_DAQ.31
DIO63: ANALOG_TO_DAQ.32
DIO64: ANALOG_TO_DAQ.33
DIO65: ANALOG_TO_DAQ.34
DIO66: ANALOG_TO_DAQ.35
DIO67: ANALOG_TO_DAQ.36
DIO68: ANALOG_TO_DAQ.37
DIO69: ANALOG_TO_DAQ.38
GND: ANALOG_TO_DAQ.1, ANALOG_TO_DAQ.2, ANALOG_TO_DAQ.12, ANALOG_TO_DAQ.13, ANALOG_TO_DAQ.14, ANALOG_TO_DAQ.29, ANALOG_TO_DAQ.30, ANALOG_TO_DAQ.39, ANALOG_TO_DAQ.40, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D8.P$1, D9.P$1, D10.P$1, D11.P$1, D12.P$1, D13.P$1, D14.P$1, D15.P$1, D16.P$1, D17.P$1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, TP.5; also elsewhere on the board
MBUS-SCL: ANALOG_TO_DAQ.4
MBUS-SDA: ANALOG_TO_DAQ.3
unnamed: PT-L02.2, R4.2, R14.2
unnamed: PT-F02.2, R2.2, R12.2
unnamed: ANALOG_TO_DAQ.5, ANALOG_TO_DAQ.6
unnamed: PT-M02.2, R8.2, R18.2
unnamed: PT-F03.2, R9.2, R19.2
unnamed: PT-F01.2, R1.2, R11.2
unnamed: PT-L01.2, R3.2, R13.2
unnamed: PT-L03.2, R5.2, R15.2
unnamed: PT-L04.2, R6.2, R16.2
unnamed: PT-M01.2, R7.2, R17.2
unnamed: PT-F04.2, R10.2, R20.2

Notes on the sheet:
Pressure Sensors
3k psi
1k psi
Thrust Plate Amp Connector
Thrust Plate Signals come from the Thrust Plate Amplifier Board. Sensors going into amp board are FC23 load cells.
1k Sensors are 824-M305100000501KPG 3k Sensors are M3051-000005-05KPG (Confirm). 4-20mA output signal.
