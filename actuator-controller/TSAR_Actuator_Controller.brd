# Repository psas/tsar-hardware (continued)

## EAGLE design tsar_SensorFrontEnd/tsar_SensorFrontEnd.brd (continued)

Parts:
C11, C13, C14, C15, C32, C33: 1u; C0603K; MPN CL10A105KB8NNNC
C12, C18, C20, C22, C29, C31, C48, C54, C57, C58, C61, C62, C65, C66: 0.1uF; C0603K; MPN CL10B104KB8NNNL
C16, C17, C19, C21, C23, C28, C34, C44, C55, C56, C59, C60, C63, C64: 0.01uF; C0603K; MPN CL10B103KB8NNNC
C30, C35, C36, C37, C38, C39, C40, C41, C42: 120pF; C0603K; MPN CL10C121JB8NNNC
C67: 1u; C0603K; MPN CL10A105KA8NNNC
C68: 22u; C0603K; MPN GRM188C60J226MEA0D
D1, D19, D20, D21, D22, D23, D24, D25, D26: D5V0H1U2LP1610-7; 0603DIODE; MPN D5V0H1U2LP1610-7
D2, D3, D4, D5, D6, D7, D28: TLVH431; SOT23-R; MPN TLVH431AIL3T
R21, R22, R25, R26, R29, R30, R33, R34, R39, R40, R50, R51, R55, R57: 100; .0603-C-NOSILK; MPN SG73P1JTTD1000F
R23, R27, R31, R42, R44, R52, R59: 1M; .0603-C-NOSILK; MPN CMP0603-FX-1004ELF
R24, R28, R32, R43, R48, R53, R63: 1K; .0603-C-NOSILK; MPN SDR03EZPJ102
R41, R47, R49, R54, R56, R58, R60, R61, R62: 1k; .0603-A-NOSILK; MPN ERJ-PA3F1001V
SERIAL_TO_DAQ: IDC_RECEPTACLE_2X20-S9175-ND; IDC_RECEPTACLES; MPN SBH11-PBPC-D20-ST-BK
TO_VI: PINHD-1X12; 1X12; MPN 1718570012
TT-F01, TT-F02: 22-23-2021
TT-L01, TT-L02, TT-L03, TT-L04, TT-L05: 22-23-2021
U1, U2, U5, U6, U7, U8, U9: AD8495ARMZ; MSOP8_0.65MM; MPN AD8495ARMZ
U3, U4: ADS7953QDBTRQ1DBT38_TEX-M; DBT38_TEX-M; MPN ADS7953QDBTRQ1
U10: REF5025AIDR; D8; MPN REF5025AIDR

Connections:
+3V3: C11.1, C13.1, C14.1, C15.1, C32.1, C33.1, U3.5 (VA+_2), U3.29 (VA+), U3.36 (VBD+), U4.5 (VA+_2), U4.29 (VA+), U4.36 (VBD+); also elsewhere on the board
+5V: C20.1, C22.1, C31.1, C54.1, C58.1, C62.1, C66.1, C67.1, R24.1, R28.1, R32.1, R43.1, R48.1, R53.1, R63.1, U1.7 (VS+), U2.7 (VS+), U5.7 (VS+), U6.7 (VS+), U7.7 (VS+), U8.7 (VS+), U9.7 (VS+), U10.2 (VIN); also elsewhere on the board
CAN0_H: SERIAL_TO_DAQ.38
CAN0_L: SERIAL_TO_DAQ.37
CH7: U4.21 (CH7)
CH15: U4.11 (CH15)
DIO32/SPI0-SCK: SERIAL_TO_DAQ.7, U3.32 (SCLK)
DIO33/SPI0-NSS: SERIAL_TO_DAQ.8, U3.31 (!CS)
DIO34/SPI0-MISO: SERIAL_TO_DAQ.9, U3.34 (SDO)
DIO35/SPI0-MOSI: SERIAL_TO_DAQ.10, U3.33 (SDI)
DIO36: SERIAL_TO_DAQ.11
DIO37: SERIAL_TO_DAQ.12
DIO39/SPI1-NSS: SERIAL_TO_DAQ.14, U4.31 (!CS)
DIO40/SPI1-MISO: SERIAL_TO_DAQ.15, U4.34 (SDO)
DIO40/SPI1-SCK: SERIAL_TO_DAQ.13, U4.32 (SCLK)
DIO41/SPI1-MOSI: SERIAL_TO_DAQ.16, U4.33 (SDI)
DIO42: SERIAL_TO_DAQ.17
DIO43: SERIAL_TO_DAQ.18
DIO44/I2C0-SDA: SERIAL_TO_DAQ.19
DIO45/I2C0-SCL: SERIAL_TO_DAQ.20
DIO46: SERIAL_TO_DAQ.21
DIO47: SERIAL_TO_DAQ.22
DIO48/UART0-TX: SERIAL_TO_DAQ.23
DIO49/UART0-RX: SERIAL_TO_DAQ.24
DIO50: SERIAL_TO_DAQ.25
DIO51: SERIAL_TO_DAQ.26
DIO52/UART1-TX: SERIAL_TO_DAQ.27
DIO53/UART1-RX: SERIAL_TO_DAQ.28
DIO54/UART1-CTS: SERIAL_TO_DAQ.29
DIO55/UART1-RTS: SERIAL_TO_DAQ.30
DIO56/UART2-TX: SERIAL_TO_DAQ.31
DIO57/UART2-RX: SERIAL_TO_DAQ.32
DIO58/UART2-CTS: SERIAL_TO_DAQ.33
DIO59/UART2-RTS: SERIAL_TO_DAQ.34
DIO60: SERIAL_TO_DAQ.35
DIO61: SERIAL_TO_DAQ.36
GND: C11.2, C13.2, C14.2, C15.2, C16.2, C17.1, C19.2, C20.2, C21.2, C22.2, C23.1, C28.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C44.1, C54.2, C55.2, C56.1, C58.2, C59.2, C60.1, C62.2, C63.2, C64.1, C66.2, C67.2, C68.2, D1.P$1, D2.3 (A), D3.3 (A), D4.3 (A), D5.3 (A), D6.3 (A), D7.3 (A), D19.P$1, D20.P$1, D21.P$1, D22.P$1, D23.P$1, D24.P$1, D25.P$1, D26.P$1, D28.3 (A), R23.1, R27.1, R31.1, R42.1, R44.1, R52.1, R59.1, SERIAL_TO_DAQ.1, SERIAL_TO_DAQ.2, SERIAL_TO_DAQ.39, SERIAL_TO_DAQ.40, TO_VI.5, TO_VI.6, TO_VI.9, U1.3 (VS-), U2.3 (VS-), U3.1 (GPIO2), U3.2 (GPIO3), U3.3 (REFM), U3.6 (AGND_2), U3.9 (AINM), U3.10 (AGND_3), U3.19 (AGND_4), U3.20 (AGND_5), U3.30 (AGND), U3.35 (BDGND)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; also elsewhere on the board
HES1: R56.2, TO_VI.1
HES1_SIGNAL: C38.1, D24.P$2, R56.1, U3.18 (CH8)
HES2: R54.2, TO_VI.2
HES2_SIGNAL: C37.1, D23.P$2, R54.1, U3.17 (CH9)
HES3: R49.2, TO_VI.3
HES3_SIGNAL: C36.1, D22.P$2, R49.1, U3.16 (CH10)
HES4: R47.2, TO_VI.4
HES4_SIGNAL: C35.1, D21.P$2, R47.1, U3.15 (CH11)
HES5: R58.2, TO_VI.7
HES5_SIGNAL: C39.1, D25.P$2, R58.1, U3.14 (CH12)
HES6: R60.2, TO_VI.8
HES6_SIGNAL: C40.1, D20.P$2, R60.1, U3.13 (CH13)
HES7: R61.2, TO_VI.10
HES7_SIGNAL: C41.1, D26.P$2, R61.1, U3.12 (CH14)
HES8: R62.2, TO_VI.11
HES8_SIGNAL: C42.1, D19.P$2, R62.1, U3.11 (CH15)
HES9: R41.2, TO_VI.12
HES9_SIGNAL: C30.1, D1.P$2, R41.1, U3.21 (CH7)
IN-: R34.1, R42.2, TT-L05.2
IN-1: R22.1, R23.2, TT-L04.2
IN-2: R26.1, R27.2, TT-L03.2
IN-3: R30.1, R31.2, TT-L02.2
IN-4: R40.1, R44.2, TT-L01.2
IN-5: R51.1, R52.2, TT-F02.2
IN-6: R57.1, R59.2, TT-F01.2
MBUS-SCL-1: SERIAL_TO_DAQ.4
MBUS-SDA-1: SERIAL_TO_DAQ.3
unnamed: U3.7 (MXO), U3.8 (AINP)
unnamed: U4.7 (MXO), U4.8 (AINP)
unnamed: C12.1, C23.2, R33.2, U1.8 (IN+)
unnamed: C12.2, C19.1, R34.2, U1.1 (IN-)
unnamed: D28.1 (VREF), D28.2 (C), R43.2, U1.2 (REF)
unnamed: C17.2, C18.1, R21.2, U2.8 (IN+)
unnamed: C16.1, C18.2, R22.2, U2.1 (IN-)
unnamed: D2.1 (VREF), D2.2 (C), R24.2, U2.2 (REF)
unnamed: C28.2, C29.1, R25.2, U5.8 (IN+)
unnamed: C21.1, C29.2, R26.2, U5.1 (IN-)
unnamed: D3.1 (VREF), D3.2 (C), R28.2, U5.2 (REF)
unnamed: C44.2, C48.1, R29.2, U6.8 (IN+)
unnamed: C34.1, C48.2, R30.2, U6.1 (IN-)
unnamed: D4.1 (VREF), D4.2 (C), R32.2, U6.2 (REF)
unnamed: C56.2, C57.1, R39.2, U7.8 (IN+)
unnamed: C55.1, C57.2, R40.2, U7.1 (IN-)
unnamed: D5.1 (VREF), D5.2 (C), R48.2, U7.2 (REF)
unnamed: C60.2, C61.1, R50.2, U8.8 (IN+)
unnamed: C59.1, C61.2, R51.2, U8.1 (IN-)
unnamed: D6.1 (VREF), D6.2 (C), R53.2, U8.2 (REF)
unnamed: C64.2, C65.1, R55.2, U9.8 (IN+)
unnamed: C63.1, C65.2, R57.2, U9.1 (IN-)
unnamed: D7.1 (VREF), D7.2 (C), R63.2, U9.2 (REF)
SEN_TBD0: U4.28 (CH0); also elsewhere on the board
SEN_TBD1: U4.27 (CH1); also elsewhere on the board
SEN_TBD2: U4.26 (CH2); also elsewhere on the board
SEN_TBD3: U4.25 (CH3); also elsewhere on the board
SEN_TBD4: U4.24 (CH4); also elsewhere on the board
SEN_TBD5: U4.23 (CH5); also elsewhere on the board
SEN_TBD6: U4.22 (CH6); also elsewhere on the board
SEN_TBD8: U4.18 (CH8); also elsewhere on the board
SEN_TBD9: U4.17 (CH9); also elsewhere on the board
SEN_TBD10: U4.16 (CH10); also elsewhere on the board
SEN_TBD11: U4.15 (CH11); also elsewhere on the board
SEN_TBD12: U4.14 (CH12); also elsewhere on the board
SEN_TBD13: U4.13 (CH13); also elsewhere on the board
SEN_TBD14: U4.12 (CH14); also elsewhere on the board
TT-F01: R55.1, TT-F01.1
TT-F01_SIGNAL: U3.28 (CH0), U9.5 (SENSE), U9.6 (OUT)
TT-F02: R50.1, TT-F02.1
TT-F02_SIGNAL: U3.27 (CH1), U8.5 (SENSE), U8.6 (OUT)
TT-L01: R39.1, TT-L01.1
TT-L01_SIGNAL: U3.26 (CH2), U7.5 (SENSE), U7.6 (OUT)
TT-L02: R29.1, TT-L02.1
TT-L03: R25.1, TT-L03.1
TT-L03_SIGNAL: U3.24 (CH4), U5.5 (SENSE), U5.6 (OUT)
TT-L04: R21.1, TT-L04.1
TT-L04_SIGNAL: U2.5 (SENSE), U2.6 (OUT), U3.23 (CH5)
TT-L05: R33.1, TT-L05.1
TT-L05_SIGNAL: U1.5 (SENSE), U1.6 (OUT), U3.22 (CH6)
TT-LO2_SIGNAL: U3.25 (CH3), U6.5 (SENSE), U6.6 (OUT)
V5D: SERIAL_TO_DAQ.5, SERIAL_TO_DAQ.6
V+: C68.1, U3.4 (REFP), U4.4 (REFP), U10.6 (VOUT)

Notes on the sheet:
Temperature via Thermocouple
-220 C
-40-25 C
Valve Position Sensors
K-Type Range = -180°C to 1200°C
With a Single 5V Supply:
1.24V REF = -248°C to 752°C
0.9V REF = -180°C to 820°C
0V REF = 0°C to 1000°C
ADCs to DAQ
All analog sensors go into the ADCs then are sent using SPI to the marionette data bus.
Temperature = (Vout - 1.25) / 0.005 V. So, for example, if the voltage is 1.5VDC, the temperature is (1.5 - 1.25) / 0.005 = 50°C
0V signal indicates the valves default position. 3.3V signal indicates the valves non-default position.

Parts:
C70, C71, C73, C74, C75, C76, C77, C78, C79, C80, C83, C84, C85, C86: 120pF; C0603K; MPN CL10C121JB8NNNC
D32, D33, D34, D35, D36, D37, D38, D39, D41, D42, D44, D45, D46, D47: D5V0H1U2LP1610-7; 0603DIODE; MPN D5V0H1U2LP1610-7
JP1: PINHD-2X12; 2X12; MPN PRPC012DAAN-RC
R65, R66, R68, R70, R71, R72, R73, R74, R78, R79, R88, R89, R90, R91: 1k; .0603-A-NOSILK; MPN ERJ-PA3F1001V

Connections:
GND: C70.2, C71.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C83.2, C84.2, C85.2, C86.2, D32.P$1, D33.P$1, D34.P$1, D35.P$1, D36.P$1, D37.P$1, D38.P$1, D39.P$1, D41.P$1, D42.P$1, D44.P$1, D45.P$1, D46.P$1, D47.P$1; also elsewhere on the board
SEN0: JP1.1, R90.2
SEN1: JP1.2, R89.2
SEN2: JP1.3, R88.2
SEN3: JP1.5, R91.2
SEN4: JP1.9, R78.2
SEN5: JP1.11, R79.2
SEN7: JP1.15, R74.2
SEN8: JP1.18, R66.2
SEN9: JP1.17, R65.2
SEN10: JP1.19, R73.2
SEN11: JP1.21, R68.2
SEN12: JP1.22, R70.2
SEN13: JP1.23, R71.2
SEN14: JP1.24, R72.2
SEN_TBD0: C85.1, D46.P$2, R90.1; also elsewhere on the board
SEN_TBD1: C84.1, D45.P$2, R89.1; also elsewhere on the board
SEN_TBD2: C83.1, D44.P$2, R88.1; also elsewhere on the board
SEN_TBD3: C86.1, D47.P$2, R91.1; also elsewhere on the board
SEN_TBD4: C79.1, D41.P$2, R78.1; also elsewhere on the board
SEN_TBD5: C80.1, D42.P$2, R79.1; also elsewhere on the board
SEN_TBD6: C78.1, D39.P$2, R74.1; also elsewhere on the board
SEN_TBD8: C71.1, D33.P$2, R66.1; also elsewhere on the board
SEN_TBD9: C70.1, D32.P$2, R65.1; also elsewhere on the board
SEN_TBD10: C77.1, D38.P$2, R73.1; also elsewhere on the board
SEN_TBD11: C73.1, D34.P$2, R68.1; also elsewhere on the board
SEN_TBD12: C74.1, D35.P$2, R70.1; also elsewhere on the board
SEN_TBD13: C75.1, D36.P$2, R71.1; also elsewhere on the board
SEN_TBD14: C76.1, D37.P$2, R72.1; also elsewhere on the board

Notes on the sheet:
Valve Position Sensors
0V signal indicates the valves default position. 3.3V signal indicates the valves non-default position.

Board: 2 copper layers, 93.3 x 94.9 mm, 261 parts (0 on the bottom side), 146 nets.

Other parts of the board:
U$5: PSAS_LOGO_10X10

## EAGLE design POE_plus_input/POE_plus_input.brd

File POE_plus_input/README.md:

# POE Plus Input Board

This board takes the main low risk POE+ 24V input and splits it off to provide 24V power to the Valve Indicator Board and the Sensor Front End board. It has a 24V to 5V regulator which provides power to the Central Manager (BB-AI) and the Sensor Front End board. 

## POE+ Block Diagram

Parts:
BBAI_5V: PINHD-1X2; 1X02; MPN 1718573002
BOOST_CAP: 0.01uF; C0805K; MPN 06035C103JAT2A
C_IN1, C_IN2: 15uF/50V; C2220K; MPN KTS500B156M55N0T00
C_IN3: 0.47uF; C0805K; MPN UMK107ABJ474KA-T
C_OUT: 47uF/16V; C1210K; MPN GRM32EC81C476KE15K
C_OUT1: 100uF/16V; C1210K; MPN EMK325ABJ107MM-P
C_OUT2: 33uF/16V; C1206K; MPN C3216X5R1C336M160AB
D1: SR305; C4111-15; MPN SR305-TP
H1, H2, H3, H4, H5, H6, H7, H8: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER
I_LIM_ADJ: 8.2k; 1206-A; MPN RC1206FR-078K2L
L1: 33uH; L_SHIELDED_13MMX13MMX6MM; MPN PE-53823SNL
PIT_GREEN: PINHD-1X2; 1X02; MPN 1718573002
POE_IN: 24V; DCJACK_2MM_SMT; MPN KLDX-SMT2-0202-ATR
SFE_5V, SFE_24V: PINHD-1X2; 1X02; MPN 1718573002
SOFTSTART: 1nF; C0603K; MPN CL10C102JB8NNNC
U1: LM2673SX-5.0/NOPB; TS7B; MPN LM2673SX-5.0/NOPB
VI_24V: PINHD-1X2; 1X02; MPN 1718573002

Connections:
+5V: BBAI_5V.1, C_OUT.1, C_OUT1.1, C_OUT2.1, L1.2, SFE_5V.1, U1.6 (FB)
+24V: C_IN1.1, C_IN2.1, C_IN3.1, PIT_GREEN.1, POE_IN.PWR1 (PWR), SFE_24V.1, U1.2 (VIN), VI_24V.1
GND: BBAI_5V.2, C_IN1.2, C_IN2.2, C_IN3.2, C_OUT.2, C_OUT1.2, C_OUT2.2, D1.A, I_LIM_ADJ.1, PIT_GREEN.2, POE_IN.GND (GNDBREAK), POE_IN.GNDBREAK (GND), SFE_5V.2, SFE_24V.2, SOFTSTART.2, U1.4 (GND), U1.8 (TAB), VI_24V.2
unnamed: SOFTSTART.1, U1.7 (SS)
unnamed: BOOST_CAP.2, D1.C, L1.1, U1.1 (SW)
unnamed: I_LIM_ADJ.2, U1.5 (ADJ)
unnamed: BOOST_CAP.1, U1.3 (CB)

Notes on the sheet:
Drill Holes for Standoffs.

Board: 2 copper layers, 93.3 x 95.1 mm, 27 parts (0 on the bottom side), 7 nets.

Other parts of the board:
U$5: PSAS_LOGO_10X10

## Commit log

2020-04-22 Adding Thrust Plate Amplifier board/schem
2020-04-23 Add files via upload
    Schematic missing connections to printer cable headers.
2020-04-23 Add files via upload
    Added AC Eagle Files to the New Locale!
2020-04-23 Added ground stitching
2020-04-23 some changes from Andrew during design review (now with supplies).
2020-04-23 Adjusting annotations
2020-04-23 Resized Schematic Frame Added connectors for Thrust Plate Input Amp Added 3v3 Regulator (missing resistor values set to TBD)
2020-04-25 Major layout changes, per design review
2020-04-25 Major thrust plate layout changes, per design review
2020-04-26 Minor Plate Amp Tweaks- improved grounding
2020-04-26 Reduced board size
    fixed missing TVS cap values
    modified board layout to reduce size
2020-04-28 Shrunk Board Layout
    Reduced size of board
    Replaced 20x2 connectors with marionette library part.
    Missing digital pin connections
2020-04-28 Labeled pressure/temp sensor limits Moved ADS pins in schematic Missing digital pin connections
2020-04-28 Updated Schematic after last design review.
    Updated according to Andrews input.
2020-04-30 changed wire size
    replaced 0603 resistors with 0805
    replaced thrust plate 4 pin connector with 6 pin
    missing digital connections
    missing mounting holes
    tvs diodes need to be replaced
2020-05-05 THE PENULTIMATE AMPLIFIER
    ALMOST ready for OSHpark. Just a few minor chores left.
2020-05-06 THE ACTUAL PENULTIMATE AMPLIFIER
    SIKE
2020-05-06 ADS connected
2020-05-07 THE ULTIMATE AMPLIFIER
2020-05-07 I broke everything
2020-05-07 Added 0603 diode library
2020-05-07 Slightly less in shambles
2020-05-09 More ADC channels usable
    Added circuitry with jumpers for the remaining 3 channels on the ADS8344.
    Changed to 5V 0603 TVS diodes.
    Added 2 pin 12V out connector for Thrust Plate Amp
2020-05-10 THE ACTUAL ULTIMATE AMPLIFIER
    Made all changes from the last design review. Added test points. Fixed isolation. Fixed TVS diode placement. Added proper mounting holes.
    Also adjusted all names on top silkscreen so they're legible and don't overlap.
2020-05-10 THE ACTUAL ULTIMATE AMPLIFIER
    Made all changes from the last design review. Added test points. Fixed isolation. Fixed TVS diode placement. Added proper mounting holes. Also adjusted all names on top silkscreen so they're legible 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
2020-05-10 Added BOM
    Starting BOM spreadsheet, to be edited into submission later.
2020-05-10 Added BOM for thrust plate amp
    Starting BOM spreadsheet, to be edited into submission later.
2020-05-12 Silk changes
2020-05-12 Replaced Resistors and 5V TVS Diodes.
    Changed resistors to 0805 to be the same size as the caps.
    Changed to a standard sized TVS Diode footprint.
    Began Board layouts.
2020-05-12 Adjusted Board Layout
2020-05-14 Completed initial board layout.
2020-05-14 Added voltage divider on GPIO Sensor Inputs.
2020-05-17 Added Second ADS8344
    Second ADS8344 on schematic
    Board Layout horribly broken
2020-05-18 Second ADS8344 layout and routing
    Layed out and routed circuits for second ADC chip
    Changed Analog connections to be more compact
    Increased size of board, vert and horz
2020-05-19 Changes to silk
2020-05-19 Revised board layout. Updated OSH Park DRC.
2020-05-25 Minor Plate Amp changes
    Un-derping
2020-05-26 Last Minute Fixes.
    Corrected Morpho Connector Spacing.
    Made all traces min 10 mil.
2020-05-26 Overthinking Tweaks
2020-05-26 Last minutes silk screen fixes.
2020-05-26 Polishing
    Moved to multiple sheets
    Font changed to vector
    resized part names and moved to be visible
2020-05-26 See last push
2020-05-26 Corrected Morpho Connector Position Again.
2020-05-26 Shuffling things around.
2020-05-26 Changed Voltage Regulator Layout
    Added Bill of Materials
    Added Digikey BOM csv for easy import
    Enlarged Text
    Added Values to all diodes
2020-05-26 Wrong Date on board
2020-05-27 Stole Conrad's stand-offs for plate amp
2020-06-01 Added ground stitching, board info, and PSAS Logo.
2020-06-05 Added BOM
2020-06-05 Updated total cost
2020-06-12 Create LICENCE
2020-09-02 Attributes Added to AC Board
2020-09-03 Added AC-board BOM
    .csv file. All NP resistors are TBD
2020-09-03 Added Attributes to TP-board
2020-09-04 Attributes for Sensor Front End Board
    Added attributes to components for BOM generation on SFE board.
    Old bill of material files moved to subfolder
2020-09-05 Fixed Inconsistency Error
    exported BOM isn't grouping like parts correctly
2020-09-08 Regulator work
2020-09-22 fixed attribute errors
2020-09-29 Fixed inconsistency error in actuator controller board
2020-10-05 approved stub warnings
2020-11-18 loto key lpkf board added
2020-11-18 adding valve indication circuit
2020-11-18 adding images and updating readme
2020-11-18 fixed typos, cleaned up images
2020-11-18 moves libraries.
2020-11-26 added v-1,v0 block diagrams
2020-11-26 typo
2020-11-28 adding diagrams
2020-11-28 diagrams added
2020-11-28 updated image
2020-12-07 updates to board, adding software build
2020-12-17 route management
2020-12-17 updated link in readme
2020-12-25 reduced AC board size, attributes, bom
2020-12-27 final error checks
2020-12-28 thick routes on AC board. protections on SFE
2020-12-28 label correction
2020-12-28 Minor cleanup around the SPS, minor polish on ground and on vbatt distribution.
2020-12-29 bom, attributes, sizing, layout
    updated BOMs, changed smds from 0805 to 0603, updated attributes, changed layout to reduce overall board size.
2021-01-15 layout, attributes, bom.
2021-01-15 replaces 4 caps with 1206 due to stock
2021-01-15 final changes to bom, tr to ct.
2021-01-21 fixed text on tplace.
2021-01-30 ac, valve indicator, libraries
    ac-board: changed attribute.
    valve-indicator V1: upgraded processor, changed buck regs, added crystal, layed out all unused processor pins, added battery power sense, updated attributes, and re-layout of entire board.
    libraries: created custom library, added new libraries.
2021-01-30 Vi silkscreen/info layout
2021-01-31 pin map to Nucleo L476RG
2021-01-31 adding isolated ps
2021-01-31 added attributes to loto
2021-02-03 sfe edits, added part library
2021-02-03 replaced ssop20 with correct package
2021-02-12 updated software links
2021-02-20 poe/ac/sfe changes, libraries
    POE low risk input board created; will manage POE+ power distribution to subsystems. added 24-> 5v regulator for SFE and BB-AI
    added libraries for SFE and POE.
    SFE: removed 24->5V regulator from SFE, replaced D27&D31 with correct package, replaced ADC to correct SSOP20 package.
    AC: replaced all passives with oresat rcl parts
2021-02-20 SFE/AC changes
    AC: began replacing nucleo with bare metal stm
    SFE: replaced all passives with oresal parts
2021-02-21 board corrections following test case.
    issue #6 closed.
2021-02-21 POE, Vi board changes
    POE Input Board: Added BB outline and mounting holes for BB-AI. Added small board standard outline and adjusted board size. Added attributes to regulator parts.
    Valve Indicator: Added small board standard outline and adjusted board size.
2021-02-22 Vi changes
    Added SD card circuit. Added 9POS for sending position sensor data to the SFE board. Updated attributes.
2021-02-22 Stnd outlines, Poe, SFE, Vi changes
    Added Standard Outline DXF files to separate folder
    POE Input Board: updated attributes, added BOM
    SFE: updated attributes, updated BOM
    Valve ind: layout changes, added attributes, updated BOM
2021-02-22 POE, SFE changes
    POE: added gnd vias and text info
    SFE: moved to mar dxf outline. removed unallocated lines and added valve position sensor pinout. updated attributes. the board is currently unrouted.
2021-02-22 SFE routes completed
2021-02-25 VI: updated attributes and layout
    Component lead time +1month, changed board for different parts.
2021-02-26 Updated LOTO boards
    Added LOTO housing outline. Added logic for POE power and gate trigger. Added more circuit protection and power isolation.
2021-02-26 Updated README's, updated/added block diagrams
2021-02-26 Block Diagrams and README's updated
2021-02-26 typo in readme
2021-03-02 AC changes. Added library
    AC: Replaced headers with STM32 processor. Began direct control connections. To Do: Need to add USB circuit. Update pinout for IDE.
    Library: added SPI compatible ADC for SFE board future revision.
2021-03-14 LOTO, Library changes
    LOTO: added attributes to lotokey board and exported BOM. Updated parts to SMD, updated attributes, completed layout/routes, and exported BOM.
    Library: CD4082 SMD AND logic gate for LOTO board added.
2021-03-18 POE, VI, and library changes
    POE Input: Corrected pad size, updated attributes, adjusted layout.
    Valve Indicator: Changed layout (sd card facing 'S').
2021-03-24 SFE changes
    Replaced ADC's with two 16 channel SPI
2021-03-25 AC, SFE, Library Changes
    AC: Reverted to headers for Nucleo. Removed sensors (data coming over usb cable to nucleo), removed power regulator (power coming from usb cable). Replaced leds with correct size and attributes.
    SFE: Removed RTD/TVS circuits. Added thermocouple inputs and thermocouple amplifier circuit. Finished ADC wiring. Added schematic info annotations. Cleaned up schematic. TODO: change labels to consis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
    Library: Added oresat-rcl library.
2021-04-03 AC, VI, library changes
    AC: attribute corrections
    VI: corrected MISO/MISI pins
    Library: Added REF5025 for ADCs on SFE board.
2021-04-03 SFE Changes
    Added amplifier circuit for thermocouples. Added reference voltage for ADCs.
2021-04-06 AC, SFE, VI changes
    AC: Added 5 pin header for sending UART status updates to the valve indicator board. Will only send the current test stand state status, so recieving data from the Vi. Routed header and added labels.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
    SFE: Routed thermocouple amps and ADCs. Made all labels consistent. Updated attributes and BOM.
    VI: Updated attributes and BOM.
2021-04-06 SFE, VI changes
    SFE: cleared errors
    VI: cleared errors
2021-04-07 AC changes
    Added 24V to 12V regulator for single 12V valve, routed, final error check. Update attributes and BOM.
2021-04-07 VI Changes
    removed vbatt sense. causes non-critical shutdown on battery power
2021-04-07 VI Changes
    removed airroutes
2021-04-07 POE, VI changes
    POE: corrected pad sizes for caps and inductor. Rerouted. Updated attributes and BOM. Final error check
    VI: changed name from valve_indicatorV1 to valve_indicator
2021-04-07 AC Changes
    Attached SOV-6 to 12V input
2021-04-07 AC Error Check
2021-04-07 AC, SFE, VI changes
    Updated rev number and dates.
2021-04-22 Readmes updated, Boms updated.
2021-04-25 AC pinout changes
    Changed SOV1 and SOV2 to different GPIO pins.
2021-04-28 Updated date on silkscreen
2022-06-29 Update README.md to include uteap report link
2024-07-30 added schematic pdfs for each board
