# Repository psas/tsar-hardware

File README.md:

# Tsar Hardware
Hardware for the Test Stand Automation and Regulation project that runs [PSAS' Liquid Fuel Engine Test Stand](https://github.com/psas/liquid-engine-test-stand)

The TSAR system controls the test stand at a safe distance with several safety features in place. The system monitors the pressure, temperature, and valve states of the system. For automation software and controls see the [tsar software repo](https://github.com/psas/tsar-software). 

The OSGC Final UTEAP Report contains more detailed information and can be found [here](https://docs.google.com/document/d/1x4pjh9ZbApyyvRd1HysukK7K5CVWpYE1/edit?usp=sharing&ouid=116385191421445654590&rtpof=true&sd=true).

## Tsar Hardware System Architecture Block Diagrams

Below you can see the levels of block diagrams for the whole system,

### V -1

### V 0

### V 1

## Systems Within the Repo

Within this repo there are several subsystems.

### [LOTO](https://github.com/psas/tsar-hardware/tree/master/LOTO)

The LOTO Repo is the Lock-Out Tag-Out subsystem.

This system prevents the test stand from being powered while key-holders are past the safety line. 

### [Thrust Plate Amplifier](https://github.com/psas/tsar-hardware/tree/master/Thrust%20Plate%20Amplifier)

The Thrust Plate Amplifier amplifies the thrust plate signal.

### [Actuator Controller](https://github.com/psas/tsar-hardware/tree/master/actuator-controller)

This board communicates with the BB-AI over UART and controls the valves. The processor is a STM32F0 using a Nucleo-board. 

For more information on the software for this board please see [Actuator Controller Code, Firmware](https://github.com/psas/tsar-software/tree/master/Actuator%20Controller%20Firmware) and [Actuator Controller Code, Test](https://github.com/psas/tsar-software/tree/master/Actuator%20Controller%20Test)

### [Tsar Sensor Front End](https://github.com/psas/tsar-hardware/tree/master/tsar_SensorFrontEnd)

This board collects the data from all of the sensors (temperature, pressure, thrust plate) and conditions the signals to send to the Marionette. 

### [Valve Indicator](https://github.com/psas/tsar-hardware/tree/master/valve_indicator)

This board collects the valve position data and compares it to the expected valve state. If there is an error it will display a code over LEDs to indicate which valve is misbehaving. 

For more information on the software for this board please see [Valve Indicator Code](https://github.com/psas/tsar-software/tree/master/valve_indicator)

## EAGLE design actuator-controller/TSAR_Actuator_Controller.brd

File actuator-controller/README.md:

# Actuator Controller

All valve and ignitor control is done via the Actuator Controller, which is currently implemented using a Nucleo mounted on a PCB. 

This board reads commands and data from the BeagleBone-AI over USB cable which it uses to switch test stand states and perform an Automatic Shutdown in the event of a system failure. Failure is defined as non-nominal sensor conditions; meaning that if pressure and/or temperature readings are outside of nominal ranges or if the physical state of the valves do not match the expected state of the valves (i.e. a valve is potentially stuck or frozen) then the system will go into an automatic shutdown state. The automatic shutdown state purges all propellants from the lines, depressurizes the system, and returns all valves to the Safety State (unpowered). This Automatic Shutdown can be triggered by the Actuator Controller automatically and it can be commanded by the user. 

The Actuator Controller requires a consistent heartbeat and emergency response code. If for some reason this heartbeat stops, or any other emergency indicator is tripped, the Actuator Controller will execute the emergency shutdown routine in accordance with the emergency response code most recently sent.

The Actuator Controller is also connected via UART to the Valve Indicator board. This connection is solely for sending the current state updates to the Valve Indicator board for other purposes. There is no data coming to the Actuator Controller from the Valve Indicator. 

The Nucleo board is powered by the USB cable from the BeagleBone-AI. The valves and ignitor are powered by a 24V power input coming from the Test Stand Battery. There is one 24V to 12V regulator on this board, it is used for an valve which runs at 12V; all other valves run at 24V. The 24V battery power is isolated from the Nucleo by the Mosfet circuits on sheet 2; the GPIO pins from the Nucleo trigger the Mosfets and allow the 24V power to switch on or restrict off the valves.

## Actuator Controller Block Diagram

## Actuator Controller Software

All actuator control software and documentation can be found [here](https://github.com/psas/tsar-software). Specifically, [the testing software](https://github.com/psas/tsar-software/tree/master/Actuator%20Controller%20Test), [the firmware](https://github.com/psas/tsar-software/tree/master/Actuator%20Controller%20Firmware), and [the state machine](https://github.com/psas/tsar-software/tree/master/state-machine)

Parts:
CN7, CN10: PINHD-2X19; 2X19; MPN PPPC192LFBN-RC
H3, H4, H5, H6: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER
JP1: PINHD-1X5; 1X05; MPN AWHW 10A-0202-T

Connections:
3V3: CN7.16
AGND: CN10.32
AVDD: CN10.7
BOOT0: CN7.7
CTS_VI: CN10.13, JP1.4
E5V: CN7.6
GND: CN7.8, CN7.19, CN7.20, CN7.22, CN10.9, CN10.20, JP1.3; also elsewhere on the board
IOREF: CN7.12
NC1: CN7.9
NC2: CN7.11
NC3: CN7.10
NC4: CN7.26
NC5: CN10.10
NC_6: CN10.36
NC_7: CN10.38
PA_0: CN7.28
PA_1: CN7.30
PA_2: CN10.35
PA_3: CN10.37
PA_4: CN7.32
PA_5: CN10.11
PA_7: CN10.15
PA_13: CN7.13
PA_14: CN7.15
PA_15: CN7.17
PB_0: CN7.34
PB_2: CN10.22
PB_3: CN10.31
PB_4: CN10.27
PB_5: CN10.29
PB_6: CN10.17
PB_7: CN7.21
PB_8: CN10.3
PB_9: CN10.5
PB_11: CN10.18
PB_12: CN10.16
PB_14: CN10.28
PC_0: CN7.38
PC_1: CN7.36
PC_2: CN7.35
PC_3: CN7.37
PC_8: CN10.2
PC_9: CN10.1
PC_10: CN7.1
PC_11: CN7.2
PC_12: CN7.3
PC_13: CN7.23
PC_14: CN7.25
PC_15: CN7.27
PD_2: CN7.4
PH_0: CN7.29
PH_1: CN7.31
RESET: CN7.14
RTS_VI: CN10.24, JP1.5
RX_VI: CN10.6, JP1.2
SOL_GPIO_0: CN10.33; also elsewhere on the board
SOL_GPIO_1: CN10.14; also elsewhere on the board
SOL_GPIO_2: CN10.12; also elsewhere on the board
SOL_GPIO_3: CN10.19; also elsewhere on the board
SOL_GPIO_4: CN10.4; also elsewhere on the board
SOL_GPIO_5: CN10.21; also elsewhere on the board
SOL_GPIO_6: CN10.23; also elsewhere on the board
SOL_GPIO_7: CN10.26; also elsewhere on the board
SOL_GPIO_8: CN10.25; also elsewhere on the board
SOL_GPIO_9: CN10.30; also elsewhere on the board
TX_VI: CN10.34, JP1.1
U5V: CN10.8
V5_INPUT: CN7.18
VBAT: CN7.33
VDD: CN7.5
VIN: CN7.24

Notes on the sheet:
STM Nucleo L476RG Morpho Connectors for the MCU Eval Board.
All Resistors and Capacitors are 0805, unless otherwise noted.
These connectors are the mounts for the STM Nucleo L476RG MCU Eval Board. The Nucleo Board is the processor which holds the state machine, controls the valves, and will read the physical valve positions.
PC_7
PA_9
PA_8
PB_10
PA_10
PC_6
PB_15
PB_13
This connector sends the current test stand state to the valve indicator board.
UART Status to VI
PA_6
PC_5
PB_1
PC_4
PA_11
PA_12

Parts:
BATTERY: CONN_02PTH4; 1X02_XTRA_BIG; MPN 282837-2
D3, D4, D5, D6, D7, D8, D9, D10, D11, D13: BAS40; SOT23; MPN CMPSH1-4 TR PBFREE
IGN: PINHD-1X2; 1X02; MPN 0022232021
Q1, Q4, Q6, Q8, Q10, Q12, Q14, Q16, Q18, Q20: 220mA/50V/3.5Ω; SOT23-3; MPN BSS138P,215
Q2, Q3, Q5, Q7, Q9, Q11, Q13, Q15, Q17, Q19: IRF9530; TO220BV; MPN IRF9530NPBF
R2, R6, R22, R25, R28, R31, R34, R37, R40, R43: 4.7K; .0805-A-NOSILK; MPN RC0805FR-074K7L
R3, R16, R23, R26, R29, R32, R35, R38, R41, R44: 10k; .0805-A-NOSILK; MPN RC0805FR-0710KL
R7, R21, R24, R27, R30, R33, R36, R39, R42, R45: 28k; .0805-A-NOSILK; MPN RMCF0805FT28K0
R17, R18, R19, R20, R59, R60, R61, R62, R63, R64: 20k; .0603-A-NOSILK; MPN ESR03EZPJ203
SOV_0., SOV_1., SOV_2., SOV_3., SOV_4., SOV_5., SOV_6., SOV_7., SOV_8., SOV_9.: Green; CHIP-LED0603; MPN 5988070107F
SOV_1, SOV_2, SOV_3, SOV_4, SOV_5, SOV_6, SOV_7, SOV_8, SOV_9: PINHD-1X2; 1X02; MPN 0022232021

Connections:
+12V: Q9.S, R28.2; also elsewhere on the board
GND: BATTERY.2, IGN.2, Q1.2 (S), Q4.2 (S), Q6.2 (S), Q8.2 (S), Q10.2 (S), Q12.2 (S), Q14.2 (S), Q16.2 (S), Q18.2 (S), Q20.2 (S), R3.1, R7.1, R16.1, R21.1, R23.1, R24.1, R26.1, R27.1, R29.1, R30.1, R32.1, R33.1, R35.1, R36.1, R38.1, R39.1, R41.1, R42.1, R44.1, R45.1, SOV_0..C, SOV_1.2, SOV_1..C, SOV_2.2, SOV_2..C, SOV_3.2, SOV_3..C, SOV_4.2, SOV_4..C, SOV_5.2, SOV_5..C, SOV_6.2, SOV_6..C, SOV_7.2, SOV_7..C, SOV_8.2, SOV_8..C, SOV_9.2, SOV_9..C; also elsewhere on the board
unnamed: Q1.3 (D), Q2.G, R6.1
unnamed: R17.1, SOV_0..A
unnamed: R18.1, SOV_4..A
unnamed: R19.1, SOV_8..A
unnamed: R20.1, SOV_9..A
unnamed: R59.1, SOV_5..A
unnamed: R60.1, SOV_1..A
unnamed: R61.1, SOV_2..A
unnamed: R62.1, SOV_6..A
unnamed: R63.1, SOV_7..A
unnamed: R64.1, SOV_3..A
unnamed: D3.1 (A), R7.2
unnamed: Q3.G, Q4.3 (D), R2.1
unnamed: D4.1 (A), R24.2
unnamed: Q5.G, Q6.3 (D), R22.1
unnamed: D5.1 (A), R27.2
unnamed: Q7.G, Q8.3 (D), R25.1
unnamed: D6.1 (A), R30.2
unnamed: Q9.G, Q10.3 (D), R28.1
unnamed: D7.1 (A), R33.2
unnamed: Q11.G, Q12.3 (D), R31.1
unnamed: D8.1 (A), R36.2
unnamed: Q13.G, Q14.3 (D), R34.1
unnamed: D9.1 (A), R39.2
unnamed: Q15.G, Q16.3 (D), R37.1
unnamed: D10.1 (A), R42.2
unnamed: Q17.G, Q18.3 (D), R40.1
unnamed: D11.1 (A), R45.2
unnamed: Q19.G, Q20.3 (D), R43.1
unnamed: D13.1 (A), R21.2
SOL_GPIO_0: Q1.1 (G), R16.2; also elsewhere on the board
SOL_GPIO_1: Q4.1 (G), R3.2; also elsewhere on the board
SOL_GPIO_2: Q6.1 (G), R23.2; also elsewhere on the board
SOL_GPIO_3: Q8.1 (G), R26.2; also elsewhere on the board
SOL_GPIO_4: Q10.1 (G), R29.2; also elsewhere on the board
SOL_GPIO_5: Q12.1 (G), R32.2; also elsewhere on the board
SOL_GPIO_6: Q14.1 (G), R35.2; also elsewhere on the board
SOL_GPIO_7: Q16.1 (G), R38.2; also elsewhere on the board
SOL_GPIO_8: Q18.1 (G), R41.2; also elsewhere on the board
SOL_GPIO_9: Q20.1 (G), R44.2; also elsewhere on the board
SOL_GPIO_10: D13.3 (C), IGN.1, Q2.D, R17.2
SOL_GPIO_11: D3.3 (C), Q3.D, R60.2, SOV_1.1
SOL_GPIO_12: D4.3 (C), Q5.D, R61.2, SOV_2.1
SOL_GPIO_13: D5.3 (C), Q7.D, R64.2, SOV_3.1
SOL_GPIO_14: D6.3 (C), Q9.D, R18.2, SOV_4.1
SOL_GPIO_15: D7.3 (C), Q11.D, R59.2, SOV_5.1
SOL_GPIO_16: D8.3 (C), Q13.D, R62.2, SOV_6.1
SOL_GPIO_17: D9.3 (C), Q15.D, R63.2, SOV_7.1
SOL_GPIO_18: D10.3 (C), Q17.D, R19.2, SOV_8.1
SOL_GPIO_19: D11.3 (C), Q19.D, R20.2, SOV_9.1
VBATT: BATTERY.1, Q2.S, Q3.S, Q5.S, Q7.S, Q11.S, Q13.S, Q15.S, Q17.S, Q19.S, R2.2, R6.2, R22.2, R25.2, R31.2, R34.2, R37.2, R40.2, R43.2; also elsewhere on the board

Notes on the sheet:
All Resistors and Capacitors are 0603 or 0805
Valve and Igniter Controls
These circuits are for controlling the 9 valves and 1 ignitor on the Test Stand. They are triggered by STM GPIOs and powered by the 24V Test Stand Battery
This is the 24V Battery which only supplies power to the valves and is controlled by STM GPIO pins. This battery is controlled by the 12V poe trigger to a solenoid relay.
Test Stand Battery (24V)
12V

Parts:
12V.REG: Green; CHIP-LED0603; MPN 5988070107F
C43: 100nF; C0603K; MPN CL10B104KB8NNNL
C45: 4.7uF; C0805K; MPN CL21A475KBQNNNE
C46: 0.1uF; C0603K; MPN CL10B104KB8NNNL
C47: 47pF; C0603K; MPN C1608C0G1H470J080AA
C50, C51: 1uF; C0603K; MPN CL10A105KB8NNNC
C52, C53: 10uF; C1206K; MPN CL31A106MBHNNNE
D31: DFLS160; POWERDI-123; MPN DFLS160-7
L3: 33uH; 0.209"LX0.197"W(5.30MMX5.00MM); MPN PM4340.333NLT
R1: 20k; .0603-A-NOSILK; MPN ERJ-PA3J203V
R69: 113k; .0805-A-NOSILK; MPN RK73H2ATTD1133F
R75: 8.2k; .0805-A-NOSILK; MPN RK73H2ATTD8201F
R76: 500k; 1206-A; MPN CRMA1206AF500KFKEF
R77: NP; .0805-A-NOSILK
R80, R81: 0; .0603-A-NOSILK; MPN RCS06030000Z0EA
U$2: MP2456GJ-P; SOT6; MPN MP2456GJ-P

Connections:
+12V: C50.1, C51.1, C52.1, C53.1, L3.2, R1.1, R69.2, R80.2; also elsewhere on the board
FLY3: C43.2, D31.C, L3.1, U$2.P$6 (SW)
GND: 12V.REG.C, C45.2, C46.2, C50.2, C51.2, C52.2, C53.2, D31.A, R75.1, R77.1, U$2.P$2 (GND); also elsewhere on the board
unnamed: 12V.REG.A, R1.2
unnamed: C43.1, R81.2
unnamed: C47.2, R69.1, R75.2, U$2.P$3 (FB)
unnamed: R76.1, R77.2, U$2.P$4 (EN)
unnamed: C47.1, R80.1
unnamed: R81.1, U$2.P$1 (BST)
VBATT: C45.1, C46.1, R76.2, U$2.P$5 (IN); also elsewhere on the board

Notes on the sheet:
24V input, 12V output voltage regulator for SOV-4 (SOV-F04), the only valve that runs at 12V.
Voltage Regulator

Board: 2 copper layers, 119.1 x 95.0 mm, 118 parts (0 on the bottom side), 64 nets.

Other parts of the board:
U$1: PSAS_LOGO_10X10

## EAGLE design valve_indicator/Schematics/valve_indicator.brd

File valve_indicator/README.md:

# Eagle Schematics & Boards

## Valve Indicator

Purpose:
This board will collect valve position data using hall effect sensors mounted on nine solenoid valves and will report the current commanded state of the valves. 
The processor will compare the expected valve states with the correct reported valve states, 
if the states do not match the processor will output an indication over the LED arrays.
The LED arrays will display specific binary codes to indicate which valve does not match. 
If multiple valves do not match then the LED arrays will display all binary codes one after another based upon priority information.

Inputs:
- POE+ 24V Power
- UART Data
- Nine Hall Effect Sensors
- ST-Link V2 Emulator

Processor:
- STM32F042K

Outputs:
- Three LED Arrays
- One Buzzer
- SD Card Data Backup

### Libraries In Use

- Power Regulators: Diodes Inc. - AZ34063UMTR-G1.lbr
- Test Points: oresat-misc.lbr
- Processor: U-ST-STM32F042K-uC.lbr
- JTAG Emulator Connector: J-Samtec-FTSH-105-XXX-DV-K-ARM-SWD.lbr
- Diode: On Semiconductor - 1N5819G.lbr

### Design Rules

We are using the OshPark design rules for a 2-layer board.

### Safety Bar Level 0 Block Diagram:

### Safety Bar Level 1 Block Diagram:

### Extra Pinout
This board is equipped with a 32 pin header to access all unused STM32 pins.

1. PB2
2. +10V
3. PB10
4. PC9
5. PB11
6. PC8
7. PB12
8. PC1
9. PB13
10. PC10
11. PB14
12. PC4
13. PB15
14. PC5
15. PC11
16. PC6
17. GND
18. PC7
19. GND
20. PC12
21. PD2
22. PC3
23. PC14-OSC32_IN
24. BOOT0
25. PC13
26. PB9
27. +3V3
28. PC0
29. PC15_OSC32_OUT
30. PC2
31. GND
32. GND

Parts:
3V3., 10V.: Green; CHIP-LED0603; MPN 5988070107F
BATT: LED1; 1X02; MPN 0022232021
C2_H, C2_L: 470pF; C0603K; MPN 0603B471K500CT
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: 10uF; C1206K; MPN CL31A106KBHNNNE
C23, C44, C45, C46, C47, C48, C49, C50, C51, C52: 47uF; C1206K; MPN C3216X5R1E476M160AC
C24, C25, C26, C27, C28, C29, C30, C31, C32, C33: 47uF; C0805K; MPN C2012X5R1A476M125AC
C34, C35, C36, C37, C38, C39, C40, C41, C42, C43: 10uF; C0805K; MPN GRM21BR61H106ME43L
D1, D2: 1N5819; SOD123; MPN 1N5819HW-7-F
D5, D6: B240A; DO214AC; MPN B240A-13-F
H4, H6, H7, H8: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER
L1, L2: 220uH; 0207/7; MPN 12RS224C
POE.: Green; CHIP-LED0603; MPN 5988070107F
POE_IN: 24V; DCJACK_2MM_SMT; MPN KLDX-SMT2-0202-ATR
R1_H, R1_L: 15k; .0805-C-NOSILK; MPN CRCW080515K0FKEAHP
R2_H: 105k; R1210; MPN ERJ-14NF1053U
R2_L: 24.6k; .0805-C-NOSILK; MPN CRCW080524K9FKEAHP
R25: 20k; .0603-C-NOSILK; MPN ESR03EZPJ203
R26, R27: 1k; .0603-C-NOSILK; MPN SDR03EZPJ102
RS_H: .33; .0603-C-NOSILK; MPN ERJ-3RQFR33V
RS_L: .33; .0603-C-NOSILK; MPN ERJ-3RQFR33V
U1, U2: MC33063ADR; D8; MPN MC33063ADR

Connections:
+3V3: C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, L1.3 (2), R2_L.2, R26.2; also elsewhere on the board
+10V: C23.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, L2.3 (2), R2_H.2, R27.2; also elsewhere on the board
GND: 3V3..C, 10V..C, BATT.2, C2_H.2, C2_L.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, D1.A, D2.A, POE..C, POE_IN.GND (GNDBREAK), POE_IN.GNDBREAK (GND), R1_H.1, R1_L.1, U1.4 (GND), U2.4 (GND); also elsewhere on the board
unnamed: RS_L.1, U1.1 (SWITCHCOLLECTOR), U1.7 (IPK), U1.8 (DRIVERCOLLECTOR)
unnamed: D1.C, L1.1, U1.2 (SWITCHEMITTER)
unnamed: C2_L.1, U1.3 (TIMINGCAPACITOR)
unnamed: R1_L.2, R2_L.1, U1.5 (COMPARATORINVERTINGINPUT)
unnamed: RS_H.1, U2.1 (SWITCHCOLLECTOR), U2.7 (IPK), U2.8 (DRIVERCOLLECTOR)
unnamed: D5.A, POE_IN.PWR1 (PWR), R25.2
unnamed: POE..A, R25.1
unnamed: D2.C, L2.1, U2.2 (SWITCHEMITTER)
unnamed: BATT.1, D6.A
unnamed: 3V3..A, R26.1
unnamed: C2_H.1, U2.3 (TIMINGCAPACITOR)
unnamed: R1_H.2, R2_H.1, U2.5 (COMPARATORINVERTINGINPUT)
unnamed: 10V..A, R27.1
POE: C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, D5.C, D6.C, RS_H.2, RS_L.2, U1.6 (VCC), U2.6 (VCC)

Notes on the sheet:
POE Connector Input
Regulator 1: POE+ 24V to 3.3V
3V3 powers all Hall Effect Sensors (HES#) & STM
POE+ Power Supply to 3.3 Hall Effect Sensor Power
POE Input 24V, Up to 30W
Regulator 2: POE+ 24V to 10V
10V power all LEDs and Buzzer
POE+ Power Supply to 10V LED Power
Battery Backup Input
Schottky Diode with 2A forward current. Safe to 40V reverse voltage. Forward voltage drop of 0.5v
This p-ch fet will be triggered by a loss of POE power. The board will run off of the battery backup and this fet will send power to the STM.
V_out = 1.25*(1+R2/R1)
Expected 33mW, 1.5mA power drain
12V
24V, Up to 30W Connector type could change
Battery Backup Signal Trigger
2092-KLDX-SMT2-0202-ACT-ND
Drill Holes for Standoffs.

Parts:
C10, C11, C12, C53, C54, C55: 100nF; C0603K; MPN CL10B104KA8NNNC
C56, C57: 20pF; C0402K; MPN CBR04C200F5GAC
C58: 10uF; C0805K; MPN CL21A106KPFNNNG
CM1: FTSH-105-XX-X-DV-K; CON10_2X5_DUK_FTSH; MPN FTSH-105-01-F-DV-K-TR
IC1: 4050D; SO16; MPN CD74HC4050M
JP2: PINHD-2X16; 2X16; MPN PRPC016DAAN-RC
R23: 1k; .0603-C-NOSILK; MPN SDR03EZPJ102
SD: LEDCHIP-LED0603; CHIP-LED0603; MPN 5988070107F
U4: STM32L476RGT6; LQFP64-10X10MM_STM; MPN STM32L476RGT6
X1: ECS-160-10-36Q-ES-TR_16MHZ; 2.5X2.0; MPN ECS-160-10-36Q-ES-TR
X2: MICROSD; MPN MEM2061-01-188-00-A

Connections:
+3V3: C10.1, C11.1, C12.1, C53.1, C55.1, C58.1, CM1.1 (VTREF), IC1.1 (VDD), JP2.27, U4.13 (VDDA/VREF+), U4.19 (VDD_2), U4.32 (VDD_3), U4.48 (VDDUSB), U4.64 (VDD), X2.4 (VDD); also elsewhere on the board
+10V: JP2.2; also elsewhere on the board
BOOT0: JP2.24, U4.60 (PH3-BOOT0)
GND: C10.2, C11.2, C12.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, CM1.3 (GND), CM1.5 (GND), CM1.9 (GNDDET), IC1.8 (VSS), IC1.11 (I), IC1.14 (I), JP2.17, JP2.19, JP2.31, JP2.32, U4.12 (VSSA/VREF-), U4.18 (VSS_2), U4.31 (VSS_3), U4.47 (VSS_4), U4.63 (VSS), X1.2 (SHIELD), X1.4 (SHIELD), X2.6 (VSS), X2.MT1 (GND), X2.MT2 (GND1); also elsewhere on the board
IN_CTS: U4.44 (PA11); also elsewhere on the board
IN_H1: U4.15 (PA1); also elsewhere on the board
IN_H2: U4.16 (PA2); also elsewhere on the board
IN_H3: U4.17 (PA3); also elsewhere on the board
IN_H4: U4.20 (PA4); also elsewhere on the board
IN_H5: U4.59 (PB7); also elsewhere on the board
IN_H6: U4.58 (PB6); also elsewhere on the board
IN_H7: U4.50 (PA15); also elsewhere on the board
IN_H8: U4.41 (PA8); also elsewhere on the board
IN_H9: U4.14 (PA0); also elsewhere on the board
IN_RTS: U4.45 (PA12); also elsewhere on the board
IN_UART-RX: U4.43 (PA10); also elsewhere on the board
IN_UART-TX: U4.42 (PA9); also elsewhere on the board
unnamed: IC1.10 (O), SD.A
unnamed: IC1.2 (O), X2.5 (SCLK)
unnamed: CM1.4 (SWDCLK/TCK), U4.49 (PA14)
unnamed: IC1.6 (O), R23.1, X2.2 (CS)
unnamed: R23.2, SD.C
unnamed: IC1.4 (O), X2.3 (DATA_IN)
unnamed: CM1.2 (SWDIO/TMS), U4.46 (PA13)
unnamed: CM1.10 (!RESET), U4.7 (NRST)
OSC_IN: C57.1, U4.5 (PH0-OSC_IN), X1.3 (2)
OSC_OUT: C56.1, U4.6 (PH1-OSC_OUT), X1.1
OUT_BUZZ: U4.26 (PB0); also elsewhere on the board
OUT_CLK: IC1.3 (I), IC1.9 (I), U4.29 (PB10)
OUT_CS: IC1.7 (I), U4.27 (PB1)
OUT_DI: IC1.5 (I), U4.10 (PC2)
OUT_DO: U4.11 (PC3), X2.7 (DATA_OUT)
OUT_LED0: U4.61 (PB8); also elsewhere on the board
OUT_LED1: U4.57 (PB5); also elsewhere on the board
OUT_LED2: U4.56 (PB4); also elsewhere on the board
OUT_LED3: U4.55 (PB3); also elsewhere on the board
PA_5: U4.21 (PA5)
PA_6: U4.22 (PA6)
PA_7: U4.23 (PA7)
PB2: JP2.1, U4.28 (PB2)
PB9: JP2.26, U4.62 (PB9)
PB10: JP2.3
PB11: JP2.5, U4.30 (PB11)
PB12: JP2.7, U4.33 (PB12)
PB13: JP2.9, U4.34 (PB13)
PB14: JP2.11, U4.35 (PB14)
PB15: JP2.13, U4.36 (PB15)
PC0: JP2.28, U4.8 (PC0)
PC1: JP2.8, U4.9 (PC1)
PC2: JP2.30
PC3: JP2.22
PC4: JP2.12, U4.24 (PC4)
PC5: JP2.14, U4.25 (PC5)
PC6: JP2.16, U4.37 (PC6)
PC7: JP2.18, U4.38 (PC7)
PC8: JP2.6, U4.39 (PC8)
PC9: JP2.4, U4.40 (PC9)
PC10: JP2.10, U4.51 (PC10)
PC11: JP2.15, U4.52 (PC11)
PC12: JP2.20, U4.53 (PC12)
PC13: JP2.25, U4.2 (PC13)
PC14-OSC32_IN: JP2.23, U4.3 (PC14-OSC32_IN)
PC15-OSC32_OUT: JP2.29, U4.4 (PC15-OSC32_OUT)
PD2: JP2.21, U4.54 (PD2)
VBATT: C54.1, U4.1 (VBAT)

Notes on the sheet:
JTAG Emulator/Code Loader
MicroSD Card

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
COPYRIGHT: Copyright (C) 2016 Accelerated Designs. All rights reserved
COPYRIGHT: Copyright (C) 2018 Accelerated Designs. All rights reserved
