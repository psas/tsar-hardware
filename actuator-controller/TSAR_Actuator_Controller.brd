File: actuator-controller/TSAR_Actuator_Controller.brd (EAGLE design)
At the start: 170.2 x 154.9 mm, 142 parts, among them Q1 220mA/50V/3.5Ω, Q10 220mA/50V/3.5Ω, Q11 IRF9530, Q12 220mA/50V/3.5Ω, Q13 IRF9530, Q14 220mA/50V/3.5Ω, Q15 IRF9530, Q16 220mA/50V/3.5Ω, Q17 IRF9530, Q18 220mA/50V/3.5Ω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

Commit message: Added voltage divider on GPIO Sensor Inputs.
Parts:
- added R49, R50, R51, R52, R53, R54, R55, R56, R57, R58: NP, rcl:R0805
- moved C24 11.6 mm to (86.6, -6.76), turned to 0 degrees
- moved C23 10.3 mm to (52.8, -3.71), turned to 0 degrees
- moved C21 3.44 mm to (74.0, -17.2), turned to 180 degrees
- moved R18 3.24 mm to (74.4, -10.9), turned to 180 degrees
- moved CR2 3.05 mm to (81.4, -4.42)
- moved C22 3.00 mm to (80.4, -7.20)
- moved CR1 3.00 mm to (48.1, -0.28)
- moved R19 1.22 mm to (86.5, -4.36), turned to 180 degrees
- moved R4 1.21 mm to (52.5, -1.15), turned to 180 degrees
Connections:
- net GND: now also R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R56.1, R57.1, R58.1
- net TBD_SENSOR_0: now also R50.2
- net TBD_SENSOR_1: now also R51.2
- net TBD_SENSOR_2: now also R52.2
- net TBD_SENSOR_3: now also R53.2
- net TBD_SENSOR_4: now also R54.2
- net TBD_SENSOR_5: now also R55.2
- net TBD_SENSOR_6: now also R56.2
- net TBD_SENSOR_7: now also R49.2
- net TBD_SENSOR_8: now also R57.2
- net TBD_SENSOR_9: now also R58.2
Routing:
- net +12V: track 35.0 -> 5.13 mm
- net +5V: track 22.0 -> 1.65 mm
- net VBATT: track 234.7 -> 255.0 mm
- net N$7: track 14.3 -> 0.59 mm
- net N$17: track 12.9 -> 19.5 mm
- net N$19: track 12.6 -> 19.0 mm
- net +3V3: track 15.6 -> 9.70 mm, vias 0 -> 2
- net TBD_SENSOR_1: track 4.87 -> 10.1 mm
- net N$6: track 7.43 -> 2.79 mm
- net TBD_SENSOR_0: track 4.87 -> 9.32 mm
- net TBD_SENSOR_3: track 4.87 -> 8.81 mm
- net TBD_SENSOR_6: track 4.87 -> 8.81 mm
- net TBD_SENSOR_5: track 4.87 -> 8.81 mm
- net TBD_SENSOR_4: track 4.87 -> 8.81 mm
- net TBD_SENSOR_2: track 4.87 -> 8.68 mm
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- added copper zone on layer 1, net +3V3
- added copper zone on layer 1, net +5V
- added copper zone on layer 1, net N$7
Other:
- board text added: "Top This Side Towards Space"

Commit message: Revised board layout. Updated OSH Park DRC.
Parts:
- removed 3V3_REG: MP2456GJ-P, TSAR_Controller:SOT6
- removed C21, C22: 0.1uF, rcl:C0805
- removed C24: 10uF, rcl:C0805
- removed C4, C5: UUX2A4R7MCL1GSCAP_UCD_8X6P2-L, TSAR_Controller:CAP_UCD_8X6P2-L
- removed CR2: 1N4148W-7-F, TSAR_Controller:SOD123
- removed D2: DFLS160, diode:DO214AA
- removed L2: 10uH, TSAR_Controller:0.209"LX0.197"W(5.30MMX5.00MM)
- removed R17: 10K, rcl:R0805
- removed R18: NP, rcl:R0805
- removed R19: 10k, rcl:R0805
- removed R20: 33k, rcl:R0805
- added C2: 4.7uF, rcl:C1206
- added H5, H6, H7: STAND-OFF, SparkFun-Hardware:STAND-OFF
- moved CN10 35.4 mm to (105.4, 52.1)
- moved CN7 35.4 mm to (44.5, 52.1)
- moved CR1 21.3 mm to (69.4, -0.39)
- moved C20 19.8 mm to (66.8, -5.78), turned to 270 degrees
- moved R50 19.1 mm to (29.2, 106.9)
- moved R57 19.1 mm to (29.2, -4.88)
- moved C1 19.1 mm to (24.8, 96.5)
- moved C13 19.1 mm to (24.8, 110.5)
- moved C40 19.1 mm to (26.0, -1.27)
- moved C41 19.1 mm to (26.0, -15.2)
- moved D14 19.1 mm to (26.0, -19.7)
- moved D17 19.1 mm to (24.8, 92.1)
- moved D18 19.1 mm to (24.8, 106.0)
- moved D22 19.1 mm to (26.0, -5.71)
- moved H3 19.1 mm to (14.0, 114.3)
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Connections:
- removed net +3V3: C24.1, CR2.2, L2.2, R19.2
- removed net N$17: 3V3_REG.P$3, R19.1, R20.2
- removed net N$5: 3V3_REG.P$4, R17.1, R18.2
- removed net N$6: 3V3_REG.P$1, C22.1, CR2.1
- removed net N$7: 3V3_REG.P$6, C22.2, D2.C, L2.1
- net +12V: now also C2.1; no longer 3V3_REG.P$5, C21.1, C4.1, C5.1, R17.2
- net GND: now also C2.2; no longer 3V3_REG.P$2, C21.2, C24.2, C4.2, C5.2, D2.A, R18.1, R20.1
Routing:
- net TBD_SENSOR_2: track 8.68 -> 123.4 mm, vias 0 -> 2
- net TBD_SENSOR_8: track 8.05 -> 116.3 mm, vias 0 -> 1
- net TBD_SENSOR_7: track 8.54 -> 104.3 mm, vias 0 -> 1
- net TBD_SENSOR_6: track 8.81 -> 98.6 mm, vias 0 -> 1
- net SOL_GPIO_0: track 2.81 -> 89.7 mm, vias 0 -> 1
- net TBD_SENSOR_5: track 8.81 -> 95.5 mm, vias 0 -> 1
- net TBD_SENSOR_3: track 8.81 -> 88.0 mm, vias 0 -> 1
- net TBD_SENSOR_0: track 9.32 -> 86.0 mm
- net SOL_GPIO_1: track 2.81 -> 76.3 mm, vias 0 -> 2
- net +5V: track 1.65 -> 68.5 mm
- net TBD_SENSOR_1: track 10.1 -> 74.6 mm
- net SOL_GPIO_2: track 2.81 -> 66.1 mm, vias 0 -> 2
- net TBD_SENSOR_9: track 8.18 -> 71.0 mm, vias 0 -> 1
- net SOL_GPIO_9: track 3.21 -> 56.0 mm
- net SOL_GPIO_8: track 4.45 -> 51.0 mm
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- removed copper zone on layer 1, net +3V3
- removed copper zone on layer 1, net N$7
Other:
- board size 170.2 x 154.9 mm -> 151.1 x 154.9 mm
