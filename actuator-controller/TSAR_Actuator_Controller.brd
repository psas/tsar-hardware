File: actuator-controller/TSAR_Actuator_Controller.brd (EAGLE design)
At the start: 119.1 x 95 mm, 99 parts, among them Q1 220mA/50V/3.5Ω, Q10 220mA/50V/3.5Ω, Q11 IRF9530, Q12 220mA/50V/3.5Ω, Q13 IRF9530, Q14 220mA/50V/3.5Ω, Q15 IRF9530, Q16 220mA/50V/3.5Ω, Q17 IRF9530, Q18 220mA/50V/3.5Ω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

Commit message: AC, SFE, VI changes
AC: Added 5 pin header for sending UART status updates to the valve indicator board. Will only send the current test stand state status, so recieving data from the Vi. Routed header and added labels. Updated attributes and BOM.
SFE: Routed thermocouple amps and ADCs. Made all labels consistent. Updated attributes and BOM.
VI: Updated attributes and BOM.
Parts:
- moved JP1 123.2 mm to (97.8, 79.1), turned to 90 degrees
- moved U$1 4.95 mm to (111.3, 83.2)
Connections:
- removed net PA_6: CN10.13
- removed net PB_1: CN10.24
- removed net PC_4: CN10.34
- removed net PC_5: CN10.6
- new net CTS_VI: CN10.13, JP1.4
- new net RTS_VI: CN10.24, JP1.5
- new net RX_VI: CN10.6, JP1.2
- new net TX_VI: CN10.34, JP1.1
- net GND: now also JP1.3
Routing:
- net TX_VI: track 0.00 -> 91.6 mm, vias 0 -> 1
- net RTS_VI: track 0.00 -> 84.3 mm
- net CTS_VI: track 0.00 -> 67.0 mm
- net RX_VI: track 0.00 -> 35.7 mm, vias 0 -> 1
- net SOL_GPIO_2: track 59.8 -> 58.3 mm
- net SOL_GPIO_1: track 52.6 -> 53.7 mm
- net SOL_GPIO_0: track 58.2 -> 59.2 mm
- net SOL_GPIO_4: track 39.8 -> 40.8 mm
Other:
- board text added: "+"
- board text added: "+ -"
- board text added: "-"
- board text added: "To Valve Indicator Board TX, RX, GND, CTS, RTS"

Commit message: AC changes
Added 24V to 12V regulator for single 12V valve, routed, final error check. Update attributes and BOM.
Parts:
- added 12V.REG: Green, led:CHIP-LED0603
- added C43: 100nF, oresat-rcl:C0603K
- added C45: 4.7uF, oresat-rcl:C0805K
- added C46: 0.1uF, oresat-rcl:C0603K
- added C47: 47pF, oresat-rcl:C0603K
- added C50, C51: 1uF, oresat-rcl:C0603K
- added C52, C53: 10uF, oresat-rcl:C1206K
- added D31: DFLS160, DFLS160-7:POWERDI-123
- added L3: 33uH, TSAR_Controller (2):0.209"LX0.197"W(5.30MMX5.00MM)
- added R1: 20k, oresat-rcl:.0603-A-NOSILK
- added R69: 113k, oresat-rcl:.0805-A-NOSILK
- added R75: 8.2k, oresat-rcl:.0805-A-NOSILK
- added R76: 500k, oresat-rcl:1206-A
- added R77: NP, oresat-rcl:.0805-A-NOSILK
- added R80, R81: 0, oresat-rcl:.0603-A-NOSILK
- added U$2: MP2456GJ-P, TSAR_Controller (2):SOT6
Connections:
- new net +12V: C50.1, C51.1, C52.1, C53.1, L3.2, R1.1, R69.2, R80.2
- new net FLY3: C43.2, D31.C, L3.1, U$2.P$6
- new net N$11: C43.1, R81.2
- new net N$12: C47.2, R69.1, R75.2, U$2.P$3
- new net N$13: R76.1, R77.2, U$2.P$4
- new net N$14: C47.1, R80.1
- new net N$15: R81.1, U$2.P$1
- new net N$3: 12V.REG.A, R1.2
- net GND: now also 12V.REG.C, C45.2, C46.2, C50.2, C51.2, C52.2, C53.2, D31.A, R75.1, R77.1, U$2.P$2
- net VBATT: now also C45.1, C46.1, R76.2, U$2.P$5
Routing:
- net VBATT: track 238.7 -> 307.6 mm
- net +12V: track 0.00 -> 53.7 mm
- net N$3: track 0.00 -> 38.9 mm
- net FLY3: track 0.00 -> 20.6 mm
- net N$13: track 0.00 -> 14.2 mm, vias 0 -> 2
- net N$12: track 0.00 -> 9.37 mm
- net N$15: track 0.00 -> 9.14 mm
- net N$14: track 0.00 -> 6.48 mm
- net N$11: track 0.00 -> 1.40 mm

Commit message: AC Changes
Attached SOV-6 to 12V input
Connections:
- net +12V: now also Q9.S, R28.2
- net VBATT: no longer Q9.S, R28.2
Routing:
- net +12V: track 53.7 -> 99.3 mm, vias 0 -> 2
- net VBATT: track 307.6 -> 288.6 mm
Changed lines of the file:
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@@
 <contactref element="Q7" pad="S"/>
 <contactref element="R25" pad="2"/>
-<contactref element="Q9" pad="S"/>
-<contactref element="R28" pad="2"/>
 <contactref element="Q11" pad="S"/>
 <contactref element="R31" pad="2"/>
@@
 <wire x1="87.122" y1="24.638" x2="98.5455" y2="24.638" width="1.27" layer="16"/>
 <wire x1="98.5455" y1="24.638" x2="98.696" y2="24.4875" width="1.27" layer="16"/>
-<wire x1="98.679" y1="37.084" x2="87.122" y2="37.084" width="1.27" layer="16"/>
 <wire x1="98.679" y1="49.53" x2="87.122" y2="49.53" width="1.27" layer="16"/>
 <wire x1="98.696" y1="62.143" x2="87.162" y2="62.143" width="1.27" layer="16"/>
@@
 <wire x1="98.696" y1="24.4875" x2="98.7195" y2="24.511" width="1.27" layer="16"/>
 <wire x1="98.7195" y1="24.511" x2="104.394" y2="24.511" width="1.27" layer="16"/>
-<wire x1="98.679" y1="37.084" x2="104.14" y2="37.084" width="1.27" layer="16"/>
 <wire x1="104.14" y1="37.084" x2="104.394" y2="36.83" width="1.27" layer="16"/>
 <wire x1="98.679" y1="49.53" x2="104.394" y2="49.53" width="1.27" layer="16"/>
@@
 <wire x1="59.263" y1="30.406325" x2="57.297075" y2="30.406325" width="1.27" layer="1"/>
 <wire x1="57.297075" y1="30.406325" x2="57.2234" y2="30.48" width="1.27" layer="1"/>
-<wire x1="59.263" y1="34.78915625" x2="57.23224375" y2="34.78915625" width="1.27" layer="1"/>
 <wire x1="57.23224375" y1="34.78915625" x2="57.2234" y2="34.798" width="1.27" layer="1"/>
 <wire x1="59.263" y1="39.1719875" x2="57.2944125" y2="39.1719875" width="1.27" layer="1"/>
@@
 <wire x1="28.524" y1="79.832" x2="36.576" y2="79.832" width="1.27" layer="1"/>
 <wire x1="25.908" y1="77.216" x2="28.524" y2="79.832" width="1.27" layer="1"/>
+<wire x1="87.122" y1="49.53" x2="87.122" y2="37.084" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="PA_1">
@@
 <wire x1="45.593" y1="67.183" x2="46.228" y2="67.183" width="0.8128" layer="1"/>
 <wire x1="46.228" y1="67.183" x2="46.852" y2="67.807" width="0.8128" layer="1"/>
-<wire x1="46.852" y1="67.807" x2="46.852" y2="72.517" width="0.8128" layer="1"/>
+<wire x1="46.852" y1="67.807" x2="46.852" y2="69.342" width="0.8128" layer="1"/>
+<wire x1="46.852" y1="69.342" x2="46.852" y2="72.517" width="0.8128" layer="1"/>
 <wire x1="44.609" y1="66.199" x2="45.593" y2="67.183" width="0.8128" layer="1"/>
 <wire x1="41.934" y1="69.596" x2="41.934" y2="68.874" width="0.8128" layer="1"/>
@@
 <wire x1="33.401" y1="78.232" x2="41.91" y2="78.232" width="0.8128" layer="1"/>
 <wire x1="41.91" y1="78.232" x2="43.067" y2="77.075" width="0.8128" layer="1"/>
+<contactref element="Q9" pad="S"/>
+<contactref element="R28" pad="2"/>
+<wire x1="59.263" y1="34.78915625" x2="60.82415625" y2="34.78915625" width="0.508" layer="1"/>
+<wire x1="60.82415625" y1="34.78915625" x2="60.833" y2="34.798" width="0.508" layer="1"/>
+<via x="60.833" y="34.798" extent="1-16" drill="0.35"/>
+<wire x1="60.833" y1="34.798" x2="61.468" y2="34.798" width="0.508" layer="16"/>
+<wire x1="62.23" y1="42.40383125" x2="62.23" y2="49.657" width="0.508" layer="16"/>
+<wire x1="61.468" y1="34.798" x2="61.7756" y2="35.1056" width="0.508" layer="16"/>
+<wire x1="61.7756" y1="35.1056" x2="61.7756" y2="41.94943125" width="0.508" layer="16"/>
+<wire x1="61.7756" y1="41.94943125" x2="62.23" y2="42.40383125" width="0.508" layer="16"/>
+<wire x1="62.23" y1="49.657" x2="51.689" y2="60.198" width="0.508" layer="16"/>
+<wire x1="51.689" y1="60.198" x2="51.689" y2="68.199" width="0.508" layer="16"/>
+<wire x1="51.689" y1="68.199" x2="50.546" y2="69.342" width="0.508" layer="16"/>
+<wire x1="50.546" y1="69.342" x2="49.657" y2="69.342" width="0.508" layer="16"/>
+<via x="49.657" y="69.342" extent="1-16" drill="0.35"/>
+<wire x1="49.657" y1="69.342" x2="46.852" y2="69.342" width="0.508" layer="1"/>
+<wire x1="60.833" y1="34.798" x2="98.679" y2="37.084" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="FLY3">
