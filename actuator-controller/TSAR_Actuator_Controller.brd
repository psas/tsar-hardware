File: actuator-controller/TSAR_Actuator_Controller.brd (EAGLE design)
At the start: 143.9 x 69 mm, 168 parts, among them Q1 220mA/50V/3.5Ω, Q10 220mA/50V/3.5Ω, Q11 IRF9530, Q12 220mA/50V/3.5Ω, Q13 IRF9530, Q14 220mA/50V/3.5Ω, Q15 IRF9530, Q16 220mA/50V/3.5Ω, Q17 IRF9530, Q18 220mA/50V/3.5Ω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

Commit message: AC changes. Added library
AC: Replaced headers with STM32 processor. Began direct control connections. To Do: Need to add USB circuit. Update pinout for IDE.
Library: added SPI compatible ADC for SFE board future revision.
Parts:
- removed CN10, CN7: (no value), pinhead:2X19
- added U1: STM32L476RGT6, STM32L476RGT6:LQFP64-10X10MM_STM
Connections:
- removed net 3V3: CN7.16
- removed net AGND: CN10.32
- removed net AVDD: CN10.7
- removed net E5V: CN7.6
- removed net IOREF: CN7.12
- removed net NC1: CN7.9
- removed net NC2: CN7.11
- removed net NC3: CN7.10
- removed net NC4: CN7.26
- removed net NC5: CN10.10
- removed net PH_0: CN7.29
- removed net PH_1: CN7.31
- removed net U5V: CN10.8
- removed net VIN: CN7.24
- new net PA_0: U1.14
- new net PA_1: U1.15
- new net PA_4: U1.20
- new net PB_0: U1.26
- new net PB_10: U1.29
- new net PB_13: U1.34
- new net PB_15: U1.36
- new net PB_6: U1.58
- new net VDDA/VREF+: U1.13
- new net VDDUSB: U1.48
- new net VDD_2: U1.19
- new net VDD_3: U1.32
- new net VSS: U1.63
- new net VSSA/VREF-: U1.12
- new net VSS_2: U1.18
- new net VSS_3: U1.31
- new net VSS_4: U1.47
- net +5V: no longer CN7.18
- net BOOT0: now also U1.60; no longer CN7.7
- net GND: no longer CN10.20, CN10.9, CN7.19, CN7.20, CN7.22, CN7.8
- net PA_11: now also U1.44; no longer CN10.14
- net PA_12: now also U1.45; no longer CN10.12
- net PA_13: now also U1.46; no longer CN7.13
- net PA_14: now also U1.49; no longer CN7.15
- net PA_15: now also U1.50; no longer CN7.17
- net PA_2: now also U1.16; no longer CN10.35
- net PA_3: now also U1.17; no longer CN10.37
- net PB_1: now also U1.27; no longer CN10.24
- net PB_11: now also U1.30; no longer CN10.18
- net PB_12: now also U1.33; no longer CN10.16
- net PB_14: now also U1.35; no longer CN10.28
- net PB_2: now also U1.28; no longer CN10.22
- net PB_3: now also U1.55; no longer CN10.31
- net PB_4: now also U1.56; no longer CN10.27
- net PB_5: now also U1.57; no longer CN10.29
- net PB_7: now also U1.59; no longer CN7.21
- net PB_8: now also U1.61; no longer CN10.3
- net PB_9: now also U1.62; no longer CN10.5
- net PC_0: now also U1.8; no longer CN7.38
- net PC_1: now also U1.9; no longer CN7.36
- net PC_10: now also U1.51; no longer CN7.1
- net PC_11: now also U1.52; no longer CN7.2
- net PC_12: now also U1.53; no longer CN7.3
- net PC_13: now also U1.2; no longer CN7.23
- net PC_14: now also U1.3; no longer CN7.25
- net PC_15: now also U1.4; no longer CN7.27
- net PC_2: now also U1.10; no longer CN7.35
- net PC_3: now also U1.11; no longer CN7.37
- net PC_8: now also U1.39; no longer CN10.2
- net PC_9: now also U1.40; no longer CN10.1
- net PD_2: now also U1.54; no longer CN7.4
- net RESET: now also U1.7; no longer CN7.14
- net SOL_GPIO_0: now also U1.21; no longer CN10.33
- net SOL_GPIO_1: now also U1.22; no longer CN10.36
- net SOL_GPIO_2: now also U1.23; no longer CN10.38
- net SOL_GPIO_3: now also U1.41; no longer CN10.19
- net SOL_GPIO_4: now also U1.42; no longer CN10.4
- net SOL_GPIO_5: now also U1.43; no longer CN10.21
- net SOL_GPIO_6: now also U1.24; no longer CN10.23
- net SOL_GPIO_7: now also U1.25; no longer CN10.26
- net SOL_GPIO_8: now also U1.37; no longer CN10.25
- net SOL_GPIO_9: now also U1.38; no longer CN10.30
- net TBD_SENSOR_0: no longer CN7.28
- net TBD_SENSOR_1: no longer CN7.30
- net TBD_SENSOR_2: no longer CN10.34
- net TBD_SENSOR_3: no longer CN10.6
- net TBD_SENSOR_4: no longer CN7.32
- net TBD_SENSOR_5: no longer CN10.11
- net TBD_SENSOR_6: no longer CN10.13
- net TBD_SENSOR_7: no longer CN10.15
- net TBD_SENSOR_8: no longer CN10.17
- net TBD_SENSOR_9: no longer CN7.34
- net VBAT: now also U1.1; no longer CN7.33
- net VDD: now also U1.64; no longer CN7.5
Routing:
- net +5V: track 91.0 -> 86.5 mm
- net TBD_SENSOR_4: track 22.0 -> 18.1 mm
- net TBD_SENSOR_9: track 39.5 -> 35.9 mm
- net SOL_GPIO_5: track 12.6 -> 9.17 mm
- net TBD_SENSOR_0: track 35.6 -> 32.9 mm
- net SOL_GPIO_2: track 61.5 -> 59.0 mm
- net SOL_GPIO_4: track 39.8 -> 37.9 mm
- net SOL_GPIO_9: track 20.8 -> 19.0 mm
- net SOL_GPIO_7: track 16.7 -> 14.9 mm
- net SOL_GPIO_0: track 58.2 -> 56.4 mm
- net SOL_GPIO_1: track 50.8 -> 49.3 mm
- net TBD_SENSOR_1: track 30.3 -> 28.9 mm
- net SOL_GPIO_8: track 19.5 -> 18.3 mm
- net SOL_GPIO_6: track 13.4 -> 12.1 mm
- net SOL_GPIO_3: track 13.1 -> 12.2 mm
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
Commit message: AC, SFE, Library Changes
AC: Reverted to headers for Nucleo. Removed sensors (data coming over usb cable to nucleo), removed power regulator (power coming from usb cable). Replaced leds with correct size and attributes.
SFE: Removed RTD/TVS circuits. Added thermocouple inputs and thermocouple amplifier circuit. Finished ADC wiring. Added schematic info annotations. Cleaned up schematic. TODO: change labels to consistent font/size. layout new components, complete attributes for new components.
Library: Added oresat-rcl library.
Parts:
- removed 12V, SENSOR0, SENSOR1, SENSOR2, SENSOR3, SENSOR4, SENSOR5, SENSOR6, SENSOR7, SENSOR8, SENSOR9: (no value), pinhead:1X02
- removed 5V., IGN., POE.: (no value), led:CHIPLED_0603
- removed 5V_REG: MP2456GJ-P, TSAR_Controller:SOT6
- removed C1, C12, C13, C14, C15, C17, C18, C19, C40, C41: 120pF, oresat-rcl:C0805K
- removed C2: 4.7uF, oresat-rcl:C1206K
- removed C20, C6: 0.1uF, oresat-rcl:C0805K
- removed C23: 10uF, oresat-rcl:C0805K
- removed C3: 47pF, oresat-rcl:C0805K
- removed CR1: 1N4148W-7-F, TSAR_Controller:SOD123
- removed D1: DFLS160, diode:DO214AA
- removed D12, D14, D15, D16, D17, D18, D19, D20, D21, D22: 5V, SparkFun-DiscreteSemi:0603
- removed H7, H8: #4-BARE_MOUNTING_HOLE/.300, mount:#4/.300-BARE+STD_NUT_OR_STAR_WASHER
- removed L1: 10uH, TSAR_Controller:0.209"LX0.197"W(5.30MMX5.00MM)
- removed R1: 10K, oresat-rcl:.0805-A-NOSILK
- removed R10, R11, R12, R14, R15, R46, R47, R48, R8, R9: 1k, oresat-rcl:.0805-A-NOSILK
- removed R13: 2.2k, oresat-rcl:.0603-C-NOSILK
- removed R4: 124k, oresat-rcl:.0805-A-NOSILK
- removed R49, R50, R51, R52, R53, R54, R55, R56, R57, R58: NP, oresat-rcl:.0805-A-NOSILK
- removed R5: 23.7k, oresat-rcl:.0805-A-NOSILK
- removed R65, R66: 0, oresat-rcl:.0805-A-NOSILK
- removed R67: 20k, oresat-rcl:.0603-A-NOSILK
- removed R68: 1k, oresat-rcl:.0603-A-NOSILK
- removed U1: STM32L476RGT6, STM32L476RGT6:LQFP64-10X10MM_STM
- added CN10, CN7: (no value), pinhead:2X19
- added H3, H4: #4-BARE_MOUNTING_HOLE/.300, mount:#4/.300-BARE+STD_NUT_OR_STAR_WASHER
- added SOV_0.: Green, led:CHIP-LED0603
- SOV_1., SOV_2., SOV_3., SOV_4., SOV_5., SOV_6., SOV_7., SOV_8., SOV_9.: value (none) -> Green; device led:CHIPLED_0603 -> led:CHIP-LED0603
- moved H6 131.9 mm to (87.0, 89.0)
- moved H5 94.0 mm to (5.99, 89.0)
- moved U$1 77.9 mm to (106.3, 83.1)
- moved D10 25.6 mm to (94.6, 17.3)
- moved D11 25.6 mm to (94.6, 11.8)
- moved D13 25.6 mm to (93.6, 68.8)
- moved D3 25.6 mm to (94.8, 61.9)
- moved D6 25.6 mm to (95.0, 44.5)
- moved D8 25.6 mm to (94.6, 29.7)
- moved D9 25.6 mm to (94.6, 23.3)
- moved IGN 25.6 mm to (115.0, 67.3)
- moved Q17 25.6 mm to (101.2, 14.6)
- moved Q5 25.6 mm to (101.2, 52.1)
- moved Q9 25.6 mm to (101.2, 39.6)
- moved R16 25.6 mm to (64.9, 54.7)
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Connections:
- removed net +12V: 12V.2, 5V_REG.P$5, C2.1, C6.1, R1.2, R67.2
- removed net +5V: C23.1, C3.2, CR1.2, L1.2, R4.1, R68.2
- removed net N$10: R12.2, SENSOR7.1
- removed net N$11: R10.2, SENSOR3.1
- removed net N$12: R48.2, SENSOR9.1
- removed net N$13: R15.2, SENSOR8.1
- removed net N$14: R9.2, SENSOR4.1
- removed net N$15: R46.2, SENSOR0.1
- removed net N$19: 5V_REG.P$3, R4.2, R5.2, R66.1
- removed net N$26: C20.1, R65.1
- removed net N$27: C3.1, R66.2
- removed net N$28: POE..A, R67.1
- removed net N$3: 5V_REG.P$4, R1.1, R13.2
- removed net N$35: 5V..A, R68.1
- removed net N$4: 5V_REG.P$1, CR1.1, R65.2
- removed net N$5: R11.2, SENSOR1.1
- removed net N$6: R14.2, SENSOR6.1
- removed net N$7: R47.2, SENSOR5.1
- removed net N$8: 5V_REG.P$6, C20.2, D1.C, L1.1
- removed net N$9: R8.2, SENSOR2.1
- removed net PA_2: U1.16
- removed net PA_3: U1.17
- removed net PB_10: U1.29
- removed net PB_13: U1.34
- removed net PB_15: U1.36
- removed net TBD_SENSOR_0: C13.1, D18.2, R46.1, R50.2
- removed net TBD_SENSOR_1: C1.1, D17.2, R11.1, R51.2
- removed net TBD_SENSOR_2: C12.1, D16.2, R52.2, R8.1
- removed net TBD_SENSOR_3: C14.1, D15.2, R10.1, R53.2
- removed net TBD_SENSOR_4: C15.1, D12.2, R12.1, R54.2
- removed net TBD_SENSOR_5: C17.1, D19.2, R47.1, R55.2
- removed net TBD_SENSOR_6: C18.1, D20.2, R14.1, R56.2
- removed net TBD_SENSOR_7: C19.1, D21.2, R49.2, R9.1
- removed net TBD_SENSOR_8: C40.1, D22.2, R15.1, R57.2
- removed net TBD_SENSOR_9: C41.1, D14.2, R48.1, R58.2
- removed net VDDA/VREF+: U1.13
- removed net VDDUSB: U1.48
- removed net VDD_2: U1.19
- removed net VDD_3: U1.32
- removed net VSS: U1.63
- removed net VSSA/VREF-: U1.12
- removed net VSS_2: U1.18
- removed net VSS_3: U1.31
- removed net VSS_4: U1.47
- new net 3V3: CN7.16
- new net AGND: CN10.32
- new net AVDD: CN10.7
- new net E5V: CN7.6
- new net IOREF: CN7.12
- new net NC1: CN7.9
- new net NC2: CN7.11
- new net NC3: CN7.10
- new net NC4: CN7.26
- new net NC5: CN10.10
- new net NC_6: CN10.36
- new net NC_7: CN10.38
- new net PA_5: CN10.11
- new net PA_6: CN10.13
- new net PA_7: CN10.15
- new net PC_4: CN10.34
- new net PC_5: CN10.6
- new net PH_0: CN7.29
- new net PH_1: CN7.31
- new net U5V: CN10.8
- new net V5_INPUT: CN7.18
- new net VIN: CN7.24
- net BOOT0: now also CN7.7; no longer U1.60
- net GND: now also CN10.20, CN10.9, CN7.19, CN7.20, CN7.22, CN7.8, SOV_0..C; no longer 12V.1, 5V..C, 5V_REG.P$2, C1.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C2.2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
- net N$2: now also SOV_0..A; no longer IGN..A
- net PA_0: now also CN7.28; no longer U1.14
- net PA_1: now also CN7.30; no longer U1.15
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Routing:
- net +12V: track 109.1 -> 0.00 mm
- net +5V: track 86.5 -> 0.00 mm
- net TBD_SENSOR_3: track 79.7 -> 0.00 mm, vias 1 -> 0
- net N$6: track 74.4 -> 0.00 mm, vias 1 -> 0
- net N$13: track 60.3 -> 0.00 mm, vias 1 -> 0
- net TBD_SENSOR_2: track 59.5 -> 0.00 mm, vias 1 -> 0
- net TBD_SENSOR_8: track 58.9 -> 0.00 mm, vias 1 -> 0
- net TBD_SENSOR_7: track 57.6 -> 0.00 mm, vias 1 -> 0
- net TBD_SENSOR_6: track 57.5 -> 0.00 mm, vias 1 -> 0
- net N$10: track 57.4 -> 0.00 mm
- net N$11: track 56.7 -> 0.00 mm, vias 1 -> 0
- net N$14: track 56.6 -> 0.00 mm, vias 1 -> 0
- net TBD_SENSOR_5: track 54.3 -> 0.00 mm, vias 1 -> 0
- net N$9: track 52.9 -> 0.00 mm, vias 1 -> 0
- net N$7: track 50.8 -> 0.00 mm, vias 1 -> 0
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Other:
- board size 143.9 x 69 mm -> 119.1 x 95 mm
- board text added: "Jennifer Jordan: jejor2@pdx.edu, github.com/psas/tsar-hardware"
- board text added: "TSAR Actuator Controller 2021-03-24, V2.1"
- board text removed: "GND"
- board text removed: "Jennifer Jordan: jejor2@pdx.edu, Jake Pratt: jakepratt42@gmail.com"
- board text removed: "TSAR Actuator Controller, 2020-12-24, v2.0"

Commit message: AC, VI, library changes
AC: attribute corrections
VI: corrected MISO/MISI pins
Library: Added REF5025 for ADCs on SFE board.
Parts:
- added JP1: (no value), pinhead:1X05
Changed lines of the file:
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@@
 <attribute name="NAME" x="85.995" y="92.5016" size="0.5" layer="33" font="vector" ratio="15"/>
+</element>
+<element name="JP1" library="pinhead" library_urn="urn:adsk.eagle:library:325" package="1X05" package3d_urn="urn:adsk.eagle:package:22469/2" value="" x="6.731" y="-3.937" smashed="yes">
+<attribute name="NAME" x="0.3048" y="-2.1082" size="1.27" layer="25" ratio="10"/>
+<attribute name="POPULARITY" value="69" x="6.731" y="-3.937" size="1.778" layer="27" display="off"/>
+<attribute name="VALUE" x="0.381" y="-7.112" size="1.27" layer="27"/>
 </element>
 </elements>
