# Repository psas/tsar-hardware (continued)

## EAGLE design LOTO/lotokey.brd

File LOTO/README.md:

# LOTO Key Indicator

There are nine of these boards mounted in the LOTO box. Each board indicates the safety keys status and powers the system if all safety keys are in place. There are LED indication lights, green indicates that the key is in place, red indicates that the key is not in place. 

## Level 0 Block Diagram

## Level 1 Block Diagram

Parts:
C1, C2, C4, C5, C7, C8, C10, C11, C13, C14, C16, C17, C19, C20, C22, C23, C25, C26: 4.7uF/25V; C050-025X075; MPN FG28X5R1E475KRT06
C3, C6, C9, C12, C15, C18, C21, C24, C27: 10uF; C050-025X075; MPN FG28X5R1E106MRT06
GREEN, GREEN1, GREEN2, GREEN3, GREEN4, GREEN5, GREEN6, GREEN7, GREEN8: TLLR4400; LED3MM; MPN TLHG5200
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10: PINHD-1X2; 1X02; MPN OSTVN02A150
JP11: PINHD-1X12; 1X12; MPN 1-640454-2
L1, L2, L3, L4, L5, L6, L7, L8, L9: 6.8uH; 0204/5; MPN B78108S1682K000
NMOS, NMOS1, NMOS2, NMOS3, NMOS4, NMOS5, NMOS6, NMOS7, NMOS8: BSS296; TO92; MPN 2N7000-G
PMOS, PMOS1, PMOS2, PMOS3, PMOS4, PMOS5, PMOS6, PMOS7, PMOS8: BSS110; TO92; MPN TP2104N3-G
PS1, PS2, PS3, PS4, PS5, PS6, PS7, PS8, PS9: PDSE1-S5-S5-S; CONV_PDSE1-S5-S5-S; MPN PDSE1-S5-S5-S
R1, R3, R4, R6, R7, R9, R10, R12, R13, R15, R16, R18, R19, R21, R22, R24, R25, R27: 1k; 0204/7; MPN CCF551K00FKE36
R2, R5, R8, R11, R14, R17, R20, R23, R26: 10k; 0204/7; MPN CCF5510K0FKE36
RED, RED1, RED2, RED3, RED4, RED5, RED6, RED7, RED8: TLLR4400; LED3MM; MPN TLUR6400

Connections:
+5V: C1.1, C4.1, C7.1, C10.1, C13.1, C16.1, C19.1, C22.1, C25.1, JP1.1, JP11.1, L1.1, L2.1, L3.1, L4.1, L5.1, L6.1, L7.1, L8.1, L9.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, JP1.2, JP11.2, JP11.3, NMOS.3 (S), NMOS1.3 (S), NMOS2.3 (S), NMOS3.3 (S), NMOS4.3 (S), NMOS5.3 (S), NMOS6.3 (S), NMOS7.3 (S), NMOS8.3 (S), PS1.1 (GND), PS1.3 (0V), PS2.1 (GND), PS2.3 (0V), PS3.1 (GND), PS3.3 (0V), PS4.1 (GND), PS4.3 (0V), PS5.1 (GND), PS5.3 (0V), PS6.1 (GND), PS6.3 (0V), PS7.1 (GND), PS7.3 (0V), PS8.1 (GND), PS8.3 (0V), PS9.1 (GND), PS9.3 (0V), R2.2, R5.2, R8.2, R11.2, R14.2, R17.2, R20.2, R23.2, R26.2, RED.K (C), RED1.K (C), RED2.K (C), RED3.K (C), RED4.K (C), RED5.K (C), RED6.K (C), RED7.K (C), RED8.K (C)
unnamed: C2.1, L1.2, PS1.2 (VIN)
unnamed: R1.2, RED1.A
unnamed: GREEN.K (C), NMOS.2 (D)
unnamed: GREEN.A, R3.2
unnamed: PMOS1.1 (S), R1.1
unnamed: C5.1, L2.2, PS2.2 (VIN)
unnamed: GREEN1.K (C), NMOS1.2 (D)
unnamed: R4.2, RED.A
unnamed: PMOS.1 (S), R4.1
unnamed: GREEN1.A, R6.2
unnamed: R7.2, RED2.A
unnamed: PMOS2.1 (S), R7.1
unnamed: C8.1, L3.2, PS3.2 (VIN)
unnamed: GREEN2.K (C), NMOS2.2 (D)
unnamed: GREEN2.A, R9.2
unnamed: R10.2, RED3.A
unnamed: PMOS3.1 (S), R10.1
unnamed: C11.1, L4.2, PS4.2 (VIN)
unnamed: GREEN3.K (C), NMOS3.2 (D)
unnamed: GREEN3.A, R12.2
unnamed: R13.2, RED4.A
unnamed: PMOS4.1 (S), R13.1
unnamed: C14.1, L5.2, PS5.2 (VIN)
unnamed: GREEN4.K (C), NMOS4.2 (D)
unnamed: GREEN4.A, R15.2
unnamed: R16.2, RED5.A
unnamed: PMOS5.1 (S), R16.1
unnamed: C17.1, L6.2, PS6.2 (VIN)
unnamed: GREEN5.K (C), NMOS5.2 (D)
unnamed: GREEN5.A, R18.2
unnamed: R19.2, RED6.A
unnamed: PMOS6.1 (S), R19.1
unnamed: C20.1, L7.2, PS7.2 (VIN)
unnamed: GREEN6.K (C), NMOS6.2 (D)
unnamed: GREEN6.A, R21.2
unnamed: R22.2, RED7.A
unnamed: PMOS7.1 (S), R22.1
unnamed: C23.1, L8.2, PS8.2 (VIN)
unnamed: GREEN7.K (C), NMOS7.2 (D)
unnamed: GREEN7.A, R24.2
unnamed: R25.2, RED8.A
unnamed: PMOS8.1 (S), R25.1
unnamed: C26.1, L9.2, PS9.2 (VIN)
unnamed: GREEN8.K (C), NMOS8.2 (D)
unnamed: GREEN8.A, R27.2
SWITCH1: C3.1, JP2.1, PMOS.3 (D), PS1.4 (+VOUT), R3.1
SWITCH2: C6.1, JP3.1, PMOS1.3 (D), PS2.4 (+VOUT), R6.1
SWITCH3: C9.1, JP4.1, PMOS2.3 (D), PS3.4 (+VOUT), R9.1
SWITCH4: C18.1, JP5.1, PMOS5.3 (D), PS6.4 (+VOUT), R18.1
SWITCH5: C15.1, JP6.1, PMOS4.3 (D), PS5.4 (+VOUT), R15.1
SWITCH6: C12.1, JP7.1, PMOS3.3 (D), PS4.4 (+VOUT), R12.1
SWITCH7: C27.1, JP8.1, PMOS8.3 (D), PS9.4 (+VOUT), R27.1
SWITCH8: C24.1, JP9.1, PMOS7.3 (D), PS8.4 (+VOUT), R24.1
SWITCH9: C21.1, JP10.1, PMOS6.3 (D), PS7.4 (+VOUT), R21.1
SW_SIG1: JP2.2, JP11.5, NMOS.1 (G), PMOS.2 (G), R5.1
SW_SIG2: JP3.2, JP11.4, NMOS1.1 (G), PMOS1.2 (G), R2.1
SW_SIG3: JP4.2, JP11.12, NMOS2.1 (G), PMOS2.2 (G), R8.1
SW_SIG4: JP5.2, JP11.10, NMOS5.1 (G), PMOS5.2 (G), R17.1
SW_SIG5: JP6.2, JP11.8, NMOS4.1 (G), PMOS4.2 (G), R14.1
SW_SIG6: JP7.2, JP11.6, NMOS3.1 (G), PMOS3.2 (G), R11.1
SW_SIG7: JP8.2, JP11.11, NMOS8.1 (G), PMOS8.2 (G), R26.1
SW_SIG8: JP9.2, JP11.9, NMOS7.1 (G), PMOS7.2 (G), R23.1
SW_SIG9: JP10.2, JP11.7, NMOS6.1 (G), PMOS6.2 (G), R20.1

Notes on the sheet:
5V DC supply from main battery
There is a key switch on the terminal block. When the switch is in the 'ON' position this circuit will light up the GREEN LED only. When the switch is in the 'OFF' position, this circuit will light up the RED LED only.
Switch Signal 2 pin from key
Switch Signal 1 pin from key

Board: 2 copper layers, 167.4 x 190.5 mm, 119 parts (0 on the bottom side), 65 nets.

## EAGLE design LOTO/logicboard.brd

Parts:
D1, D2: CGRM4001-G; SOD-123_MINI-SMA; MPN CMHSH5-4 TR PBFREE
E_STOP: PINHD-1X2; 1X02; MPN OSTVN02A150
H1, H2, H3, H4: MOUNT-HOLE2.8; 2,8
JP1: PINHD-1X12; 1X12; MPN 1-640454-2
POE+_INJ: PINHD-1X2; 1X02; MPN 0022232021
POE+_PS: PINHD-1X2; 1X02; MPN OSTVN02A150
POE_INJ: PINHD-1X2; 1X02; MPN 0022232021
Q1, Q4: 220mA/50V/3.5Ω; SOT23-3; MPN BSS138P,215
Q2, Q3: IRF9530; TO220BV; MPN IRF9530NPBF
R1, R3: 4.7K; .0805-C-NOSILK; MPN RC0805FR-074K7L
R12, R16: 10k; .0805-C-NOSILK; MPN RC0805FR-0710KL
R13, R21: 28k; .0805-C-NOSILK; MPN RMCF0805FT28K0
R_S1, R_S2, R_S3, R_S4, R_S5, R_S6, R_S7, R_S8, R_S9: 1k; .0603-C-NOSILK; MPN ERJ-PA3F1001V
U1, U2: CD4082BNSR; NS14; MPN CD4082BNSR

Connections:
+5V: JP1.1, U1.14 (VDD), U2.14 (VDD)
GND: E_STOP.2, JP1.2, JP1.3, POE+_INJ.2, POE+_PS.2, POE_INJ.2, Q1.2 (S), Q4.2 (S), R12.1, R13.1, R16.1, R21.1, U1.7 (VSS), U2.7 (VSS)
unnamed: JP1.4, R_S8.1
unnamed: JP1.5, R_S4.1
unnamed: JP1.6, R_S7.1
unnamed: JP1.7, R_S3.1
unnamed: JP1.8, R_S2.1
unnamed: JP1.9, R_S1.1
unnamed: JP1.10, R_S6.1
unnamed: JP1.11, R_S9.1
unnamed: JP1.12, R_S5.1
unnamed: Q1.3 (D), Q2.G, R1.1
unnamed: U1.5 (A), U2.1 (J)
unnamed: U1.13 (K), U2.5 (A)
unnamed: D1.A, R13.2
unnamed: Q3.G, Q4.3 (D), R3.1
unnamed: D2.A, R21.2
ON: Q1.1 (G), Q4.1 (G), R12.2, R16.2, U1.1 (J)
S1: R_S1.2, U1.4 (B)
S2: R_S2.2, U1.3 (C)
S3: R_S3.2, U1.2 (D)
S4: R_S4.2, U2.3 (C)
S5: R_S5.2, U1.9 (E)
S6: R_S6.2, U1.11 (G), U1.12 (H)
S7: R_S7.2, U2.4 (B)
S8: R_S8.2, U2.2 (D)
S9: R_S9.2, U1.10 (F)
SOL_GPIO_1: D1.C, POE_INJ.1, Q3.D
SOL_GPIO_10: D2.C, POE+_INJ.1, Q2.D
VCC: E_STOP.1, Q3.S, R3.2
VDD: POE+_PS.1, Q2.S, R1.2

Notes on the sheet:
Main Logic
Power Inputs
This circuit is triggered by the logic output. If 'on' the power from the POE+ (power switch) will be connected, if 'off' the POE+ injector will be off.
This circuit is triggered by the logic output. If 'on' the power from the POE (e-stop) will be connected, if 'off' the POE injector will be off.
These are the three power inputs. The POE+_PS is from the POE+ Power Switch. The E_STOP is from the emergency stop button. The 5V USB power goes into the Main Logic input header. The switches are connected to the POE injectors respective power supplies.
This circuit has the 9 key switch inputs going into AND logic gates. Only when all 9 key switches are in the LOTO box and turned does the logic signal send a logic 'on' trigger.

Board: 2 copper layers, 58.4 x 41.6 mm, 32 parts (0 on the bottom side), 31 nets.

## EAGLE design Thrust Plate Amplifier/ThrustAmpV1.brd

File Thrust Plate Amplifier/README.md:

# Thrust Plate Amplifier

This board amplifies the signals of the four load cells present on the thrust plate. The thrust plate measures the thrust of the liquid fuel engine. The load cells are compression only using part number FC2311-0000-1000-L. The signals from the amplifier are sent to the Sensor Front End board. This amplifier board must be as close as possible to the load cells on the thrust plate; otherwise the signals will be degraded and invalid. 

The thrust plate amplifier is powered by the Sensor Front End board's 12V rail.

## POE+ Block Diagram

Parts:
C1: 4.7 uF; C0805; MPN CL21A475KAQNNNE
C2: 100 nF; C0805; MPN 08055D104KAT2A
C3: 22 uF; C0805; MPN CL21A226KPCLRNC
C4, C11: 10 nF; C0805; MPN C2012X5R2E103K125AA
C5, C12: 1 uF; C0805; MPN CL21A105KACLNNC
C6, C13: 2.2 uF; C0805; MPN CL21A225KAFNNNG
C7, C8, C9, C10, C19, C20, C22: 100 nF; C0805K; MPN 08055D104KAT2A
C14, C15, C16, C17: 120 pF; C0805; MPN C0805C121KDRACTU
C18, C23, C24, C25, C26, C27, C28, C29: 100 pF; C0805K; MPN 885012207054
CR1: 1N4148W-7-F; SOD123; MPN 1N4148W-7-F
D1: 10BQ060TR; SMB; MPN 10BQ060TR
D2, D3, D4, D5, D6, D7, D8, D10, D11, D12, D13, D14, D15, D16: D5V0H1U2LP1610-7; 0603DIODE; MPN D5V0H1U2LP1610-7
D9: D12V0H1U2LP1610-70603DIODE12V; 0603DIODE; MPN D12V0H1U2LP1610-7
H5, H6, H7, H8: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER
J1: CONN_02PTH3; 1X02_LONGPADS; MPN 22232021
J2: CONN_05PTH_LONGPADS; 1X05_LONGPADS; MPN 0022232051
J4, J5, J6, J7: CONN_04; 1X04; MPN 0022232041
R1, R2, R3, R4: TBD; R0805
R5, R6, R7, R8, R9, R10, R11, R12: NP; 0207/5V
R13, R18, R19, R20: 1 K; R0805; MPN RC0805FR-071KL
R14: 19.1 k; R0805; MPN RNCP0805FTD19K1
R15: NP; R0805
R16: 124k; R0805; MPN RK73H2ATTD1243F
R17: 499 k; R0805; MPN RK73H2ATTD4993F
TP1, TP2, TP3, TP4: TEST-POINTTP_15TH_THRU; TP_15TH
U1, U2, U3, U4: INA126PA; P8; MPN INA126PA
U5: LP2985AIM5-3.3; MF05A; MPN LP2985AIM5-3.3/NOPB
U6: LP2985AIM5-5.0/NOPB; MF05A; MPN LP2985AIM5-5.0/NOPB
U$1: MP2456GJ-P; SOT6; MPN MP2456GJ-P
U$2: CLF5030NIT-100M-D; 0.209"LX0.197"W(5.30MMX5.00MM); MPN CLF5030NIT-100M-D

Connections:
3.3V: C7.1, C8.1, C9.1, C10.1, C13.1, TP4.P$1, U1.7 (V+), U2.7 (V+), U3.7 (V+), U4.7 (V+), U5.5 (VOUT)
5V: C6.1, C12.1, C19.1, C20.1, D15.P$2, D16.P$2, J4.1, J5.1, J6.1, J7.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, TP3.P$1, U5.1 (VIN), U5.3 (ON), U6.5 (VOUT)
6V: C3.1, C5.1, CR1.2, R16.2, TP2.P$1, U6.1 (VIN), U6.3 (ON), U$2.2
12V: C1.1, C22.1, D9.P$2, J1.2, R17.2, TP1.P$1, U$1.P$5 (IN)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, D1.A, D2.P$1, D3.P$1, D4.P$1, D5.P$1, D6.P$1, D7.P$1, D8.P$1, D9.P$1, D10.P$1, D11.P$1, D12.P$1, D13.P$1, D14.P$1, D15.P$1, D16.P$1, J1.1, J2.5, J4.4, J5.4, J6.4, J7.4, R14.1, R15.2, U1.4 (V-), U1.5 (REF), U2.4 (V-), U2.5 (REF), U3.4 (V-), U3.5 (REF), U4.4 (V-), U4.5 (REF), U5.2 (GND), U6.2 (GND), U$1.P$2 (GND)
unnamed: R1.2, U1.8 (RG)
unnamed: R1.1, U1.1 (RG_2)
unnamed: R2.2, U2.8 (RG)
unnamed: R2.1, U2.1 (RG_2)
unnamed: R3.2, U3.8 (RG)
unnamed: R3.1, U3.1 (RG_2)
unnamed: R4.2, U4.8 (RG)
unnamed: R4.1, U4.1 (RG_2)
unnamed: R14.2, R16.1, U$1.P$3 (FB)
unnamed: C2.1, CR1.1, U$1.P$1 (BST)
unnamed: R13.2, U1.6 (VO)
unnamed: R18.2, U2.6 (VO)
unnamed: R19.1, U3.6 (VO)
unnamed: R20.1, U4.6 (VO)
unnamed: C16.2, D5.P$2, J2.1, R13.1
unnamed: C15.2, D6.P$2, J2.2, R18.1
unnamed: C2.2, D1.C, U$1.P$6 (SW), U$2.1
unnamed: C14.1, D3.P$2, J2.3, R19.2
unnamed: C17.1, D4.P$2, J2.4, R20.2
unnamed: C11.1, U5.4 (BP)
unnamed: C4.1, U6.4 (BP)
unnamed: R15.1, R17.1, U$1.P$4 (EN)
unnamed: C18.1, D11.P$2, J4.2, R5.2, U1.3 (V+IN)
unnamed: C26.1, D10.P$2, J4.3, R6.2, U1.2 (V-IN)
unnamed: C23.1, D12.P$2, J5.2, R7.2, U2.3 (V+IN)
unnamed: C27.1, D8.P$2, J5.3, R8.2, U2.2 (V-IN)
unnamed: C24.1, D13.P$2, J6.2, R9.2, U3.3 (V+IN)
unnamed: C28.1, D7.P$2, J6.3, R10.2, U3.2 (V-IN)
unnamed: C25.1, D14.P$2, J7.2, R11.2, U4.3 (V+IN)
unnamed: C29.1, D2.P$2, J7.3, R12.2, U4.2 (V-IN)

Notes on the sheet:
Thrust Plate Power Supply: 5V
Amplifier Power Supply: 3.3 V
Thrust Plate Connector and Bridge Biasing Resistors
Data Out
Thrust Plate Amplifier and Power Supply Board
Designed by Mike Hall for 2019-2020 TSAR ECE Capstone
Step-Down Switching Regulator (6V)
Power In (12 V)
All resistors are 0805 1% unless otherwise specified. All capacitors are 0805 10% X5R with working voltage 25 V unless otherwise specified.

Board: 2 copper layers, 101.6 x 76.2 mm, 87 parts (0 on the bottom side), 35 nets.

## EAGLE design valve_indicator/Schematics/valve_indicator 2.brd

Board: 2 copper layers, 85.1 x 53.6 mm, 87 parts (0 on the bottom side), 49 nets.

Parts:
BATT: LED1; 1X02
C0_H, C0_L: 10uF; C1206
C1, C2, C3, C4, C5, C6, C7, C8, C9: 4.7nF; C0603
C1_H, C1_L: 100uF; C025-025X050
C2_H, C2_L: 470pF; C0603
C3_H, C3_L: 470uF; C0603
C10, C11, C12: 100nF; C0603
CM1: FTSH-105-XX-X-DV-K; CON10_2X5_DUK_FTSH
D1, D2: 1N5819G_0_0; ON_SEMICONDUCTOR_1N5819G_0
D3: SB240; DO41-7.6
H1, H2, H3, H5: MOUNT-HOLE2.8; 2,8
HES1: HES1; 1X03
HES2: HES2; 1X03
HES3: HES3; 1X03
HES4: HES4; 1X03
HES5: HES5; 1X03
HES6: HES6; 1X03
HES7: HES7; 1X03
HES8: HES8; 1X03
HES9: HES9; 1X03
JP2: PF0-OSC_IN_PIN; 1X01
JP3: PF1-OSC_OUT_PIN; 1X01
JP4: PB8-BOOT0_PIN; 1X01
L1, L2: 220uH; 0204/5
LED_BUS: LEDS; 2X04
POE_IN: 24V; DCJACK_2MM_SMT
Q1, Q2, Q3, Q4: PMV45EN2R; SOT23
R1, R2, R3, R4, R5, R6, R7, R8, R9, R14, R15, R16, R17, R18: 10k; R0603
R1_H: 3.3k; R0603
R1_L: 3.6k; R0603
R2_H: 470; R0603
R2_L: 2.2k; R0603
R10, R11, R12, R13: 1k; R0603
RS_H: .33; R0603
RS_L: .33; R0603
SD_CARD: SD; 1X06
SM_STAT: SM_STAT; 1X05
TP3V3, TP3V3J, TP10V: TEST-POINT-LARGE-SQUARE; 1X01
TPBASE: TEST-POINT-LARGE-SQUARE; 1X01
TPJGND: TEST-POINT-LARGE-SQUARE; 1X01
TPNRST: TEST-POINT-LARGE-SQUARE; 1X01
TPOE: TEST-POINT-LARGE-SQUARE; 1X01
TPSCLK: TEST-POINT-LARGE-SQUARE; 1X01
TPSIO: TEST-POINT-LARGE-SQUARE; 1X01
U1, U2: AZ34063UMTR-G1; DIODES_INC._AZ34063UMTR-G1_0
U3: STM32F042K6; QFP32-7X7

Connections:
+3V3: C3_L.1, C10.1, C11.1, C12.1, CM1.1, L1.2, R1.1, R1_L.2, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, SD_CARD.6, TP3V3.1, TP3V3J.1, U3.1, U3.5, U3.17
+10V: C3_H.1, HES1.1, HES2.1, HES3.1, HES4.1, HES5.1, HES6.1, HES7.1, HES8.1, HES9.1, L2.2, LED_BUS.2, LED_BUS.4, LED_BUS.6, LED_BUS.8, R1_H.2, TP10V.1
BUZZ: LED_BUS.1, R13.2
CLK: SD_CARD.4, U3.11
CS: SD_CARD.1, U3.15
CTS: SM_STAT.4, U3.21
DI: SD_CARD.2, U3.13
DO: SD_CARD.3, U3.12
GND: BATT.2, C0_H.2, C0_L.2, C1.2, C1_H.2, C1_L.2, C2.2, C2_H.2, C2_L.2, C3.2, C3_H.2, C3_L.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, CM1.3, CM1.5, CM1.9, D1.1, D2.1, HES1.2, HES2.2, HES3.2, HES4.2, HES5.2, HES6.2, HES7.2, HES8.2, HES9.2, POE_IN.GND, POE_IN.GNDBREAK, Q1.2, Q2.2, Q3.2, Q4.2, R2_H.1, R2_L.1, R15.1, R16.1, R17.1, R18.1, SD_CARD.5, SM_STAT.3, TPJGND.1, U1.4, U2.4, U3.16, U3.32
H1: C1.1, HES1.3, R1.2, U3.7
H2: C2.1, HES2.3, R2.2, U3.8
H3: C3.1, HES3.3, R3.2, U3.9
H4: C4.1, HES4.3, R4.2, U3.10
H5: C5.1, HES5.3, R5.2, U3.30
H6: C6.1, HES6.3, R6.2, U3.29
H7: C7.1, HES7.3, R7.2, U3.25
H8: C8.1, HES8.3, R8.2, U3.18
H9: C9.1, HES9.3, R9.2, U3.6
LED1: LED_BUS.7, R10.2
LED2: LED_BUS.5, R11.2
LED3: LED_BUS.3, R12.2
unnamed: Q4.3, R13.1
unnamed: RS_L.2, U1.1, U1.7, U1.8
unnamed: C2_L.1, U1.3
unnamed: R1_L.1, R2_L.2, U1.5
unnamed: D1.2, L1.1, U1.2
unnamed: JP2.1, U3.2
unnamed: JP3.1, U3.3
unnamed: JP4.1, U3.31
unnamed: CM1.4, TPSCLK.1, U3.24
unnamed: Q3.3, R12.1
unnamed: BATT.1, D3.A
unnamed: RS_H.2, U2.1, U2.7, U2.8
unnamed: C2_H.1, U2.3
unnamed: R1_H.1, R2_H.2, U2.5
unnamed: D2.2, L2.1, U2.2
unnamed: Q1.1, R15.2, U3.28
unnamed: Q3.1, R17.2, U3.26
unnamed: Q1.3, R10.1
unnamed: Q2.3, R11.1
unnamed: CM1.2, TPSIO.1, U3.23
unnamed: CM1.10, TPNRST.1, U3.4
unnamed: Q4.1, R18.2, U3.14
unnamed: Q2.1, R16.2, TPBASE.1, U3.27
POE: C0_H.1, C0_L.1, C1_H.1, C1_L.1, D3.C, POE_IN.PWR1, RS_H.1, RS_L.1, TPOE.1, U1.6, U2.6
RTS: SM_STAT.5, U3.22
UART-RX: R14.2, U3.20
UART-TX: SM_STAT.1, U3.19
UART_RX: R14.1, SM_STAT.2
