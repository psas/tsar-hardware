File: tsar_SensorFrontEnd/tsar_SensorFrontEnd.brd (EAGLE design)
At the start: 165.4 x 87.6 mm, 129 parts

Commit message: Slightly less in shambles
Parts:
- removed H1, H2, H3, H4: MOUNT-HOLE4.5, holes:4,5
- removed TVS1, TVS10, TVS2, TVS3, TVS4, TVS5, TVS6, TVS7, TVS8, TVS9: DF2B5M4CT,L3F, TSAR_Controller:SOD-882(SOT2)
- added D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D2, D3, D4, D5, D6, D7, D8, D9: (no value), D5V0H1U2LP1610-7:0603DIODE
- added JP1, JP2, JP3: (no value), adafruit:1X03
- moved C13 3.56 mm to (58.2, 31.4)
- moved C14 3.56 mm to (41.0, 24.3)
- moved C11 3.56 mm to (56.9, 25.8)
- moved C12 3.56 mm to (42.1, 31.5)
- moved U$3 3.56 mm to (49.3, 27.8)
- moved R41 2.90 mm to (5.84, 57.4)
- moved C30 1.83 mm to (8.89, 56.4), turned to 0 degrees
- moved C4 1.05 mm to (102.3, 52.5)
- moved R20 1.05 mm to (136.3, 65.9)
- moved C9 0.51 mm to (130.7, 52.7)
- moved C1 0.51 mm to (100.5, 25.0)
- moved C6 0.38 mm to (130.6, 25.0)
- moved C8 0.25 mm to (143.4, 42.8)
- moved R17 0.25 mm to (136.1, 39.2)
- moved R18 0.25 mm to (142.4, 48.1)
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Connections:
- new net N$36: JP3.2, R53.2
- new net N$37: JP1.2, R51.2
- new net N$39: JP2.2, R52.2
- new net N$41: JP3.1
- new net N$42: JP3.3
- new net N$43: JP2.1
- new net N$44: JP2.3
- new net N$45: JP1.1
- new net N$47: JP1.3
- net +5V: no longer R51.2, R52.2, R53.2
- net 1: now also D8.P$2; no longer TVS1.P$1
- net 10: now also D17.P$2; no longer TVS10.P$1
- net 11: now also D2.P$2
- net 12: now also D18.P$2
- net 13: now also D1.P$2
- net 19: now also D3.P$2
- net 2: now also D9.P$2; no longer TVS2.P$1
- net 3: now also D10.P$2; no longer TVS3.P$1
- net 4: now also D11.P$2; no longer TVS4.P$1
- net 5: now also D12.P$2; no longer TVS5.P$1
- net 6: now also D13.P$2; no longer TVS6.P$1
- net 7: now also D14.P$2; no longer TVS7.P$1
- net 8: now also D15.P$2; no longer TVS8.P$1
- net 9: now also D16.P$2; no longer TVS9.P$1
- net GND: now also D1.P$1, D10.P$1, D11.P$1, D12.P$1, D13.P$1, D14.P$1, D15.P$1, D16.P$1, D17.P$1, D18.P$1, D2.P$1, D3.P$1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; no longer TVS1.P$2, TVS10.P$2, TVS2.P$2, TVS3.P$2, TVS4.P$2, TVS5.P$2, TVS6.P$2, TVS7.P$2, TVS8.P$2, TVS9.P$2
- net N$21: now also D7.P$2
- net N$23: now also D6.P$2
- net N$24: now also D5.P$2
- net N$25: now also D4.P$2
Routing:
- net 13: track 0.00 -> 60.1 mm
- net 12: track 0.00 -> 40.3 mm
- net 11: track 2.68 -> 37.0 mm
- net 19: track 3.67 -> 35.2 mm
- net N$25: track 2.55 -> 32.6 mm
- net N$24: track 2.63 -> 22.9 mm
- net N$23: track 2.78 -> 20.4 mm
- net GND: track 45.5 -> 30.6 mm, vias 35 -> 21
- net N$21: track 2.75 -> 17.2 mm
- net +5V: track 77.9 -> 63.9 mm
- net N$34: track 11.6 -> 17.4 mm
- net CRYO2: track 6.97 -> 12.3 mm
- net CRYO4: track 6.97 -> 12.3 mm
- net AMBIENT: track 7.12 -> 12.3 mm
- net CRYO1: track 7.04 -> 12.2 mm
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
Commit message: More ADC channels usable
Added circuitry with jumpers for the remaining 3 channels on the ADS8344.
Changed to 5V 0603 TVS diodes.
Added 2 pin 12V out connector for Thrust Plate Amp
Parts:
- removed R45, R46, R47, R48, R49, R50: NP, Resistor_Capacitor:RES_0805
- added JP4, JP5, JP6: (no value), adafruit:1X03
- added THRUSTPOWER: 22-23-2021, con-molex:22-23-2021
- R51, R52, R53: value 150 -> TBD
- moved R42 7.11 mm to (27.7, 47.5), turned to 0 degrees
- moved R39 5.18 mm to (26.7, 45.5), turned to 180 degrees
- moved R41 4.75 mm to (7.11, 52.8)
- moved R44 4.75 mm to (13.7, 52.8)
- moved D1 4.75 mm to (9.91, 49.3)
- moved C30 4.75 mm to (10.2, 51.8)
- moved C28 4.06 mm to (26.7, 42.9)
- moved D2 4.06 mm to (26.7, 39.1)
- moved OPEN3 2.62 mm to (12.4, 61.2)
- moved R53 2.62 mm to (13.7, 67.3)
- moved POE_BYPASS 1.52 mm to (77.7, 79.2)
- moved POE 1.27 mm to (84.8, 79.2)
- moved R51 1.02 mm to (27.4, 69.6)
- moved C12 0.51 mm to (41.6, 31.5)
- turned JP1 to 270 degrees
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Connections:
- removed net N$30: R40.2, R47.1, R48.1
- removed net N$31: R41.2, R49.1, R50.1
- removed net N$43: JP2.1
- removed net N$44: JP2.3
- removed net N$45: JP1.1
- removed net N$47: JP1.3
- net +12V: now also JP1.1, JP2.1, JP3.1, THRUSTPOWER.1
- net +5V: now also JP1.3, JP2.3, JP3.3
- net GND: now also THRUSTPOWER.2
- net N$26: now also JP4.3; no longer R46.2
- net N$27: now also JP5.3; no longer R47.2
- net N$28: now also JP6.3; no longer R50.2
- net N$32: now also JP4.2; no longer R45.1, R46.1
- net N$33: now also JP6.1; no longer R49.2
- net N$34: now also JP5.1; no longer R48.2
- net N$35: now also JP4.1; no longer R45.2
- net N$41: now also JP5.2, R40.2; no longer JP3.1
- net N$42: now also JP6.2, R41.2; no longer JP3.3
Routing:
- net +5V: track 63.9 -> 195.3 mm, vias 1 -> 2
- net +12V: track 179.2 -> 263.5 mm
- net N$11: track 0.00 -> 44.5 mm
- net N$18: track 0.00 -> 33.2 mm, vias 0 -> 1
- net N$13: track 0.00 -> 30.6 mm, vias 0 -> 1
- net N$17: track 0.00 -> 30.5 mm, vias 0 -> 1
- net N$20: track 0.14 -> 30.1 mm, vias 0 -> 1
- net 8: track 31.0 -> 52.1 mm
- net N$30: track 13.6 -> 0.00 mm
- net N$36: track 0.00 -> 13.4 mm, vias 0 -> 1
- net N$31: track 13.3 -> 0.00 mm
- net N$37: track 0.00 -> 11.7 mm, vias 0 -> 1
- net N$39: track 0.00 -> 11.6 mm, vias 0 -> 1
- net N$26: track 7.57 -> 18.5 mm
- net N$28: track 2.63 -> 11.9 mm
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
Commit message: Silk changes
Parts:
- added H1, H2, H3, H4: #4-BARE_MOUNTING_HOLE/.300, mount:#4/.300-BARE+STD_NUT_OR_STAR_WASHER
- added U$6: (no value), NBitWonder:OSHW1
- added U$7: (no value), psas-logo:PSAS_LOGO_15X15
Connections:
- net GND: now also ANALOG_TO_DAQ.1, ANALOG_TO_DAQ.12, ANALOG_TO_DAQ.13, ANALOG_TO_DAQ.14, ANALOG_TO_DAQ.2, ANALOG_TO_DAQ.29, ANALOG_TO_DAQ.30, ANALOG_TO_DAQ.39, ANALOG_TO_DAQ.40, SERIAL_TO_DAQ.1, SERIAL_TO_DAQ.2, SERIAL_TO_DAQ.39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
Routing:
- net +5V: track 195.3 -> 192.3 mm
Other:
- board text added: "TSAR capstone 2019-2020 Sensor Front End Board REV 0"
Changed lines of the file:
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@@
 <layer number="134" name="silk_top" color="7" fill="1" visible="no" active="no"/>
 <layer number="135" name="silk_bottom" color="7" fill="1" visible="no" active="no"/>
-<layer number="136" name="silktop" color="7" fill="1" visible="no" active="yes"/>
+<layer number="136" name="silktop" color="7" fill="1" visible="yes" active="yes"/>
 <layer number="137" name="silkbottom" color="7" fill="1" visible="no" active="yes"/>
 <layer number="140" name="Testjig_Mill" color="26" fill="1" visible="no" active="yes"/>
@@
 <wire x1="165.379721875" y1="87.5536" x2="0" y2="87.5536" width="0" layer="20"/>
 <wire x1="0" y1="87.5536" x2="0" y2="0" width="0" layer="20"/>
+<text x="3.302" y="26.924" size="1.778" layer="136" font="vector">TSAR capstone 2019-2020
+Sensor Front End Board
+REV 0</text>
 </plain>
 <attributes>
@@
 <attribute name="VALUE" x="93.98" y="74.168" size="1.016" layer="27" ratio="10"/>
 </element>
+<element name="U$6" library="NBitWonder" package="OSHW1" value="" x="25.184" y="14.1" smashed="yes"/>
+<element name="H1" library="mount" package="#4/.300-BARE+STD_NUT_OR_STAR_WASHER" value="#4-BARE_MOUNTING_HOLE/.300" x="8.382" y="8.128" smashed="yes">
+<attribute name="NAME" x="11.2395" y="10.9855" size="1.27" layer="25" font="vector"/>
+<attribute name="NAME" x="7.382" y="11.628" size="0.5" layer="33" font="vector" ratio="15"/>
+<attribute name="VALUE" x="11.557" y="4.953" size="1.27" layer="27" font="vector"/>
+</element>
+<element name="H2" library="mount" package="#4/.300-BARE+STD_NUT_OR_STAR_WASHER" value="#4-BARE_MOUNTING_HOLE/.300" x="157.226" y="8.128" smashed="yes">
+<attribute name="NAME" x="160.0835" y="10.9855" size="1.27" layer="25" font="vector"/>
+<attribute name="NAME" x="156.226" y="11.628" size="0.5" layer="33" font="vector" ratio="15"/>
+<attribute name="VALUE" x="160.401" y="4.953" size="1.27" layer="27" font="vector"/>
+</element>
+<element name="H3" library="mount" package="#4/.300-BARE+STD_NUT_OR_STAR_WASHER" value="#4-BARE_MOUNTING_HOLE/.300" x="6.096" y="81.788" smashed="yes">
+<attribute name="NAME" x="8.9535" y="84.6455" size="1.27" layer="25" font="vector"/>
+<attribute name="NAME" x="5.096" y="85.288" size="0.5" layer="33" font="vector" ratio="15"/>
+<attribute name="VALUE" x="9.271" y="78.613" size="1.27" layer="27" font="vector"/>
+</element>
+<element name="H4" library="mount" package="#4/.300-BARE+STD_NUT_OR_STAR_WASHER" value="#4-BARE_MOUNTING_HOLE/.300" x="158.75" y="82.296" smashed="yes">
+<attribute name="NAME" x="161.6075" y="85.1535" size="1.27" layer="25" font="vector"/>
+<attribute name="NAME" x="157.75" y="85.796" size="0.5" layer="33" font="vector" ratio="15"/>
+<attribute name="VALUE" x="161.925" y="79.121" size="1.27" layer="27" font="vector"/>
+</element>
+<element name="U$7" library="psas-logo" package="PSAS_LOGO_15X15" value="" x="6.604" y="10.668" smashed="yes"/>
 </elements>
 <signals>
@@
 <contactref element="C22" pad="2"/>
 <contactref element="R34" pad="1"/>
-<wire x1="45.9994" y1="23.1606" x2="46.1264" y2="23.2876" width="0.1524" layer="1"/>
-<wire x1="47.2694" y1="23.1606" x2="47.3964" y2="23.2876" width="0.1524" layer="1"/>
 <via x="56.9214" y="28.0416" extent="1-16" drill="0.35"/>
 <contactref element="C25" pad="2"/>
@@
 <contactref element="D17" pad="P$1"/>
 <contactref element="THRUSTPOWER" pad="2"/>
+<contactref element="ANALOG_TO_DAQ" pad="1"/>
+<contactref element="ANALOG_TO_DAQ" pad="13"/>
+<contactref element="ANALOG_TO_DAQ" pad="29"/>
+<contactref element="ANALOG_TO_DAQ" pad="39"/>
+<contactref element="ANALOG_TO_DAQ" pad="40"/>
+<contactref element="ANALOG_TO_DAQ" pad="30"/>
+<contactref element="ANALOG_TO_DAQ" pad="12"/>
+<contactref element="ANALOG_TO_DAQ" pad="14"/>
+<contactref element="ANALOG_TO_DAQ" pad="2"/>
+<contactref element="SERIAL_TO_DAQ" pad="1"/>
+<contactref element="SERIAL_TO_DAQ" pad="39"/>
+<contactref element="SERIAL_TO_DAQ" pad="2"/>
+<contactref element="SERIAL_TO_DAQ" pad="40"/>
 </signal>
 <signal name="1">
@@
 <contactref element="C4" pad="1"/>
 <via x="101.092" y="50.8" extent="1-16" drill="0.35"/>
-<wire x1="101.092" y1="50.8" x2="100.584" y2="33.274" width="0.254" layer="16"/>
-<wire x1="100.584" y1="33.274" x2="116.2558" y2="17.6022" width="0.254" layer="16"/>
+<wire x1="101.092" y1="50.8" x2="101.092" y2="33.274" width="0.254" layer="16"/>
+<wire x1="101.092" y1="33.274" x2="101.077690625" y2="32.780309375" width="0.254" layer="16"/>
+<wire x1="101.077690625" y1="32.780309375" x2="116.2558" y2="17.6022" width="0.254" layer="16"/>
 <wire x1="101.092" y1="52.2072" x2="101.092" y2="50.8" width="0.254" layer="1"/>
 <wire x1="101.3358" y1="52.451" x2="101.092" y2="52.2072" width="0.254" layer="1"/>
@@
 <contactref element="R33" pad="1"/>
 <contactref element="U$1" pad="P$4"/>
-<wire x1="73.1266" y1="53.761640625" x2="73.152" y2="53.736240625" width="0.508" layer="1"/>
 <polygon width="0.1524" layer="1" thermals="no">
 <vertex x="72.136" y="53.848"/>
@@
 <wire x1="43.5864" y1="30.6959" x2="43.5864" y2="32.2626" width="0.508" layer="1"/>
 <wire x1="67.6656" y1="62.1944" x2="67.1932" y2="61.722" width="0.508" layer="1"/>
-<wire x1="67.1932" y1="61.722" x2="64.262" y2="61.722" width="0.508" layer="1"/>
 <wire x1="67.6656" y1="62.1944" x2="69.3776" y2="62.1944" width="0.508" layer="1"/>
 <wire x1="69.3776" y1="62.1944" x2="69.596" y2="61.976" width="0.508" layer="1"/>
@@
 <contactref element="CR2" pad="1"/>
 <contactref element="C24" pad="1"/>
-<wire x1="73.6578" y1="47.5742" x2="73.6578" y2="47.498" width="0.1524" layer="1"/>
 <polygon width="0.1524" layer="1" thermals="no">
 <vertex x="78.486" y="45.466"/>
@@
 </drawing>
 <compatibility>
+<note version="6.3" minversion="6.2.2" severity="warning">
+Since Version 6.2.2 text objects can contain more than one line,
+which will not be processed correctly with this version.
+</note>
 <note version="8.2" severity="warning">
 Since Version 8.2, EAGLE supports online libraries. The ids
