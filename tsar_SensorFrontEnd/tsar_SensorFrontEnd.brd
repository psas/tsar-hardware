File: tsar_SensorFrontEnd/tsar_SensorFrontEnd.brd (EAGLE design)
At the start: 165.4 x 87.6 mm, 140 parts

Commit message: Added Second ADS8344
Second ADS8344 on schematic
Board Layout horribly broken
Parts:
- removed HP1, HP2, HP3, HP4, HP5, LP3, LP4, LP5: 22-23-2021, con-molex:22-23-2021
- added C31: 0.1u, rcl:C0805K
- added C32, C33, C34: 1u, rcl:C0805K
- added C35, C36, C37, C38, C39, C40, C41, C42: 120pF, rcl:C0805
- added D19, D20, D21, D22, D23, D24, D25, D26: (no value), D5V0H1U2LP1610-7:0603DIODE
- added H5, H6: #4-BARE_MOUNTING_HOLE/.300, mount:#4/.300-BARE+STD_NUT_OR_STAR_WASHER
- added JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP21, JP23, JP24, JP25, JP26, JP27, JP7, JP8, JP9: (no value), adafruit:1X03
- added OPEN10, OPEN11, OPEN4, OPEN5, OPEN6, OPEN7, OPEN8, OPEN9, PIT2, PIT5, PIT6, PT1, PT2, PT3, PT4, PT5: 22-23-2021, con-molex:22-23-2021
- added R45, R46, R48, R50, R55, R57, R59, R63, R64, R65, R66, R67, R68, R70, R71, R72, R73, R74: NP, marionette:.0805-B
- added R47, R49, R54, R56, R58, R60, R61, R62: 1k, marionette:.0805-B
- added U$8: ADS8344, TSAR_Controller:SSOP-20
- C1: value 120pF -> 120p
- D8: value (none) -> 1
- R1, R2: value 150 -> NP
- R42, R43, R44: value 1k -> NP
- R51, R52, R53: value TBD -> NP
- moved C10 110.2 mm to (247.6, 61.3)
- moved C4 110.2 mm to (212.5, 53.2)
- moved C6 110.2 mm to (240.8, 25.8)
- moved C7 110.2 mm to (247.6, 34.7)
- moved C8 110.2 mm to (253.7, 43.6)
- moved D13 110.2 mm to (240.5, 27.9)
- moved D14 110.2 mm to (246.9, 36.8)
- moved D16 110.2 mm to (240.5, 55.1)
- moved R3 110.2 mm to (226.5, 52.5)
- moved R4 110.2 mm to (212.5, 61.8)
- moved R8 110.2 mm to (255.2, 52.5)
- moved THRUST 110.2 mm to (262.6, 28.7)
- moved ANALOG_TO_DAQ 110.2 mm to (225.2, 9.42)
- moved C2 110.2 mm to (218.9, 34.7)
- moved C3 110.2 mm to (225.2, 43.6)
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Connections:
- new net 14: C35.1, D21.P$2, R47.1, U$8.4
- new net 15: C40.1, D20.P$2, R60.1, U$8.6
- new net 16: C41.1, D26.P$2, R61.1, U$8.7
- new net 17: C42.1, D19.P$2, R62.1, U$8.8
- new net 18: C36.1, D22.P$2, R49.1, U$8.3
- new net 20: C37.1, D23.P$2, R54.1, U$8.2
- new net 21: C38.1, D24.P$2, R56.1, U$8.1
- new net 22: C39.1, D25.P$2, R58.1
- new net N$43: JP7.2, R45.2
- new net N$44: JP8.3, LP1.1, R45.1
- new net N$45: JP9.1, LP2.1, R46.1
- new net N$47: JP10.2, R46.2
- new net N$48: JP9.3, LP2.2, R2.2
- new net N$49: JP8.1, LP1.2, R1.2
- new net N$50: SERIAL_TO_DAQ.13, U$8.19
- new net N$51: C38.2, D24.P$1
- new net N$52: SERIAL_TO_DAQ.15, U$8.15
- new net N$53: SERIAL_TO_DAQ.14, U$8.18
- new net N$54: SERIAL_TO_DAQ.12, U$8.16
- new net N$55: JP13.2, R68.2
- new net N$56: SERIAL_TO_DAQ.16, U$8.17
- new net N$57: JP12.2, R67.2
- new net N$58: JP11.2, R66.2
- new net N$59: JP14.3, OPEN4.2, R63.2
- new net N$60: JP15.3, OPEN5.2, R64.2
- new net N$61: JP16.3, OPEN6.2, R65.2
- new net N$62: JP16.1, OPEN6.1, R68.1
- new net N$63: JP15.1, OPEN5.1, R67.1
- new net N$64: JP14.1, OPEN4.1, R66.1
- new net N$65: JP17.3, OPEN7.2, R48.2
- new net N$66: JP17.1, OPEN7.1, R73.1
- new net N$67: JP17.2, R47.2
- new net N$68: JP14.2, R60.2
- new net N$69: JP15.2, R61.2
- new net N$70: JP16.2, R62.2
- new net N$71: JP18.3, OPEN8.2, R50.2
- new net N$72: JP18.1, OPEN8.1, R72.1
- new net N$73: JP18.2, R49.2
- new net N$74: JP19.3, OPEN9.2, R55.2
- new net N$75: JP19.1, OPEN9.1, R71.1
- new net N$76: JP19.2, R54.2
- new net N$77: JP20.3, OPEN10.2, R57.2
- new net N$78: JP20.1, OPEN10.1, R70.1
- new net N$79: JP20.2, R56.2
- new net N$80: JP21.3, OPEN11.2, R59.2
- new net N$81: JP21.1, OPEN11.1, R74.1
- new net N$82: JP21.2, R58.2
- new net N$86: JP11.3, JP12.3, JP13.3
- new net N$87: JP24.2, R71.2
- new net N$88: JP23.2, R70.2
- new net N$93: JP27.2, R74.2
- new net N$94: JP26.2, R73.2
- new net N$95: JP25.2, R72.2
- net +12V: now also JP10.3, JP23.3, JP24.3, JP25.3, JP26.3, JP27.3, JP7.1, PIT2.1, PIT5.1, PIT6.1, PT1.1, PT2.1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; no longer HP1.1, HP2.1, HP3.1, HP4.1, HP5.1, LP1.1, LP2.1, LP3.1, LP4.1, LP5.1
- net +3V3: now also C32.1, C33.1, U$8.11
- net +5V: now also C31.1, C34.1, JP10.1, JP11.1, JP12.1, JP13.1, JP23.1, JP24.1, JP25.1, JP26.1, JP27.1, JP7.3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
- net GND: now also C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C39.2, C40.2, C41.2, C42.2, D19.P$1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
- net N$1: now also PT2.2; no longer LP4.2
- net N$19: now also JP8.2; no longer LP1.2, R1.2
- net N$2: now also JP9.2; no longer LP2.2, R2.2
- net N$22: now also PT1.2; no longer LP3.2
- net N$29: now also PT3.2; no longer LP5.2
- net N$38: now also PT4.2; no longer HP1.2
- net N$40: now also PT5.2; no longer HP2.2
- net N$46: now also PIT6.2; no longer HP5.2
- net N$6: now also PIT2.2; no longer HP3.2
- net N$7: now also PIT5.2; no longer HP4.2
Routing:
- net N$12: track 65.1 -> 30.4 mm
- net +12V: track 263.5 -> 230.9 mm
- net N$19: track 9.08 -> 0.00 mm
- net N$30: track 0.00 -> 2.03 mm
- net N$2: track 15.7 -> 14.4 mm

Commit message: Second ADS8344 layout and routing
Layed out and routed circuits for second ADC chip
Changed Analog connections to be more compact
Increased size of board, vert and horz
Parts:
- moved R73 332.8 mm to (118.1, 72.1), turned to 90 degrees
- moved JP26 329.2 mm to (118.1, 77.7), turned to 180 degrees
- moved R72 315.1 mm to (118.1, 61.5), turned to 90 degrees
- moved JP25 314.9 mm to (118.1, 67.6), turned to 180 degrees
- moved JP24 294.4 mm to (118.1, 55.1), turned to 180 degrees
- moved JP27 292.8 mm to (90.9, 43.4), turned to 180 degrees
- moved R71 291.2 mm to (118.1, 48.8), turned to 90 degrees
- moved R74 291.1 mm to (90.9, 38.6), turned to 90 degrees
- moved R70 280.7 mm to (118.1, 35.6), turned to 90 degrees
- moved JP23 276.9 mm to (118.1, 41.1), turned to 180 degrees
- moved D25 264.2 mm to (109.7, 42.4), turned to 90 degrees
- moved R59 258.6 mm to (106.2, 36.6), turned to 180 degrees
- moved D24 256.8 mm to (137.2, 40.9), turned to 90 degrees
- moved R58 255.3 mm to (104.6, 42.2), turned to 270 degrees
- moved R57 252.7 mm to (136.1, 34.5), turned to 180 degrees
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Connections:
- removed net N$86: JP11.3, JP12.3, JP13.3
- new net 0: C39.2, D25.P$1
- net +12V: now also JP11.3, JP12.3, JP13.3
- net 22: now also U$8.5
- net GND: no longer C39.2, D25.P$1, U$8.5
Routing:
- net +5V: track 192.3 -> 396.3 mm
- net +12V: track 230.9 -> 333.1 mm
- net 14: track 0.00 -> 94.0 mm, vias 0 -> 2
- net 18: track 0.00 -> 87.7 mm, vias 0 -> 2
- net 20: track 0.00 -> 83.3 mm, vias 0 -> 2
- net 10: track 81.6 -> 4.78 mm, vias 1 -> 0
- net 21: track 0.00 -> 75.8 mm, vias 0 -> 2
- net N$52: track 0.00 -> 67.4 mm, vias 0 -> 1
- net 17: track 0.00 -> 67.1 mm, vias 0 -> 2
- net N$50: track 0.00 -> 64.7 mm, vias 0 -> 1
- net N$16: track 63.2 -> 0.00 mm
- net N$14: track 61.1 -> 0.00 mm
- net N$15: track 60.4 -> 0.00 mm
- net N$54: track 0.00 -> 60.3 mm, vias 0 -> 2
- net 16: track 0.00 -> 58.1 mm, vias 0 -> 2
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Other:
- board size 165.4 x 87.6 mm -> 190.5 x 94.7 mm

Commit message: Changes to silk
Parts:
- moved C32 99.8 mm to (84.6, 35.6), turned to 90 degrees
- moved C34 96.4 mm to (87.1, 35.3), turned to 90 degrees
- moved C33 92.0 mm to (82.3, 30.5), turned to 270 degrees
- moved C31 83.0 mm to (87.2, 18.4), turned to 270 degrees
- moved H4 13.5 mm to (183.4, 87.6)
- moved H3 3.59 mm to (6.86, 85.3)
- moved U$6 3.34 mm to (25.7, 17.4)
- moved H6 3.25 mm to (85.6, 86.6)
- moved THRUST 2.29 mm to (167.9, 20.8)
- moved U$7 2.09 mm to (6.10, 12.7)
- moved H1 1.80 mm to (7.11, 6.86)
- moved R4 0.25 mm to (156.4, 69.0)
Connections:
- removed net 0: C39.2, D25.P$1
- removed net N$51: C38.2, D24.P$1
- net GND: now also C38.2, C39.2, D24.P$1, D25.P$1
Routing:
- net 10: track 4.78 -> 118.7 mm, vias 0 -> 2
- net 9: track 5.29 -> 110.9 mm, vias 0 -> 2
- net 8: track 5.76 -> 102.6 mm, vias 0 -> 2
- net 4: track 4.86 -> 90.9 mm, vias 0 -> 3
- net N$15: track 0.00 -> 85.8 mm
- net 5: track 5.08 -> 88.6 mm, vias 0 -> 1
- net 3: track 5.71 -> 88.9 mm, vias 0 -> 3
- net 2: track 4.85 -> 85.7 mm, vias 0 -> 3
- net N$12: track 0.00 -> 75.6 mm, vias 0 -> 1
- net N$16: track 0.00 -> 75.0 mm, vias 0 -> 2
- net 1: track 4.92 -> 75.9 mm, vias 0 -> 2
- net 7: track 6.06 -> 72.7 mm, vias 0 -> 2
- net N$14: track 0.00 -> 58.4 mm, vias 0 -> 2
- net 6: track 5.70 -> 63.3 mm
- net +5V: track 396.3 -> 434.2 mm, vias 2 -> 3
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Other:
- board text added: "TSAR capstone 2019-2020 Sensor Front End Board REV 0 18-05-20"
- board text removed: "TSAR capstone 2019-2020 Sensor Front End Board REV 0"

Commit message: Polishing
Moved to multiple sheets
Font changed to vector
resized part names and moved to be visible
Parts:
- removed 123132: DFLS160, diode:DO214AA
- added DFLS160_: DFLS160, diode:DO214AA
- CR1, CR2: device TSAR_Controller (2):SOD123 -> TSAR_Controller:SOD123
- moved THRUSTPOWER 150.0 mm to (184.2, 24.1)
- moved CR1 18.8 mm to (67.6, 40.9)
- moved H6 14.5 mm to (73.0, 79.4)
- moved CR2 13.7 mm to (65.0, 59.4), turned to 90 degrees
- moved H4 8.31 mm to (184.1, 79.3)
- moved POE 7.22 mm to (63.8, 76.7)
- moved POE_BYPASS 6.48 mm to (65.8, 69.6), turned to 180 degrees
- moved H3 5.97 mm to (6.38, 79.4)
- moved H5 4.39 mm to (88.9, 6.37)
- moved U$6 3.82 mm to (21.9, 17.1)
- moved U$7 3.57 mm to (2.54, 13.0)
- moved H2 1.07 mm to (184.1, 6.27)
- moved H1 0.93 mm to (6.32, 6.37)
- renumbered LP1 to OPENHS2, LP2 to OPENHS1
Connections:
- net 1 renamed ADC1.0
- net 10 renamed ADC0.4
- net 2 renamed ADC1.1
- net 3 renamed ADC1.2
- net 4 renamed ADC1.3
- net 5 renamed ADC1.4
- net 6 renamed ADC1.5
- net 7 renamed ADC1.6
- net 8 renamed ADC0.6
- net 9 renamed ADC0.5
- net GND1 renamed FLY2
- net N$11 renamed DIO32/SPI0-SCK
- net N$12 renamed ADC0.0
- net N$13 renamed DIO35/SPI0-MOSI
- net N$14 renamed ADC0.2
- net N$15 renamed ADC0.3
- net N$16 renamed ADC0.1
- net N$17 renamed DIO34/SPI0-MISO
- net N$18 renamed DIO33/SPI0-NSS
- net N$20 renamed DIO36
- net N$50 renamed DIO40/SPI1-SCK
- net N$52 renamed DIO40/SPI1-MISO
- net N$53 renamed DIO39/SPI1-NSS
- net N$54 renamed DIO37
- net N$56 renamed DIO41/SPI1-MOSI
- removed net GND2: 123132.C, C24.2, U$4.P$6, U$5.1
- new net FLY1: C24.2, DFLS160_.C, U$4.P$6, U$5.1
- net +3V3: now also CR1.2; no longer CR2.2
- net +5V: now also CR2.2; no longer CR1.2
- net GND: now also DFLS160_.A; no longer 123132.A
- net N$3: now also CR2.1; no longer CR1.1
- net N$4: now also CR1.1; no longer CR2.1
Routing:
- net +12V: track 359.2 -> 422.4 mm
- net +5V: track 434.2 -> 442.4 mm
- net ADC0.1: track 75.0 -> 73.0 mm
- net ADC0.0: track 75.6 -> 74.6 mm
- net GND: vias 4 -> 65
- added copper zone on layer 1, net FLY1
- removed copper zone on layer 1, net GND2
Other:
- board size 190.5 x 94.7 mm -> 190.5 x 85.1 mm
- board text added: "12V"
- board text added: "12v"
- board text added: "5V"
