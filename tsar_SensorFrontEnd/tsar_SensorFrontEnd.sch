File: tsar_SensorFrontEnd/tsar_SensorFrontEnd.sch (EAGLE design)
At the start: 238 parts, among them U1 ADS8344N, U2 ADS8344N

Commit message: poe/ac/sfe changes, libraries
POE low risk input board created; will manage POE+ power distribution to subsystems. added 24-> 5v regulator for SFE and BB-AI
added libraries for SFE and POE.
SFE: removed 24->5V regulator from SFE, replaced D27&D31 with correct package, replaced ADC to correct SSOP20 package.
AC: replaced all passives with oresat rcl parts
Parts:
- removed C15: 100nF, rcl:C-USC0603
- removed C19: 10uF, rcl:R-US_R1206
- removed C22: 4.7uF, rcl:C-USC0805
- removed C23: 0.1uF, rcl:C-USC0603
- removed C48: 47pF, rcl:C-USC0603
- removed D28: DFLS160, diode:DIODE-DO214AA
- removed D29: 1N4148W-7-F, TSAR_Controller:1N4148W-7-F
- removed JP1, JP2, JP4, JP5: (no value), adafruit:PINHD-1X3
- removed L2: 10uH, TSAR_Controller (2):CLF5030NIT-100M-D
- removed OPEN1, OPEN2: 22-23-2021, con-molex:22-23-2021
- removed R33: 500k, rcl:R-US_R1206
- removed R34, R42, R43, R51, R52: NP, rcl:R-US_R0603
- removed R78, R79: 0, rcl:R-US_R0603
- removed U$1: MP2456GJ-P, TSAR_Controller (2):MP2456GJ-P
- added AMBIENT2, CRYO5: 22-23-2021, con-molex:22-23-2021
- added POE_IB_5V: (no value), pinhead:PINHD-1X2
- D27, D31: device diode:DIODE-DO214AA -> DFLS160-7:DFLS160-7
- R26: value 124k -> 150; DPN 2019-RK73H2ATTD1243FCT-ND -> RNCP0805FTD150RCT-ND; MFR KOA Speer Electronics, Inc. -> Stackpole Electronics Inc; MPN RK73H2ATTD1243F -> RNCP0805FTD150R
- R30: value 23.7k -> 22k; DPN 2019-RK73H2ATTD2372FCT-ND -> 311-22.0KCRCT-ND; MFR KOA Speer Electronics, Inc. -> Yageo; MPN RK73H2ATTD2372F -> RC0805FR-0722KL
Connections:
- removed net FLY2: C15.2, D28.C, L2.1, U$1.SW
- removed net N$10: R33.1, R34.2, U$1.EN
- removed net N$17: C15.1, R78.1
- removed net N$26: JP4.3, OPEN1-2.S, R42.2
- removed net N$27: JP5.3, OPEN2-2.S, R43.2
- removed net N$3: D29.1, R78.2, U$1.BST
- removed net N$35: JP4.1, OPEN1-1.S, R51.1
- removed net N$37: JP1.2, R51.2
- removed net N$39: JP2.2, R52.2
- removed net N$41: JP5.2, R40.2
- removed net N$9: C48.2, R26.1, R30.2, U$1.FB
- new net CAN0_H: SERIAL_TO_DAQ.38
- new net CAN0_L: SERIAL_TO_DAQ.37
- new net DAC0: ANALOG_TO_DAQ.7
- new net DAC1: ANALOG_TO_DAQ.8
- new net DAC2: ANALOG_TO_DAQ.9
- new net DAC3: ANALOG_TO_DAQ.10
- new net DIO42: SERIAL_TO_DAQ.17
- new net DIO43: SERIAL_TO_DAQ.18
- new net DIO44/I2C0-SDA: SERIAL_TO_DAQ.19
- new net DIO45/I2C0-SCL: SERIAL_TO_DAQ.20
- new net DIO46: SERIAL_TO_DAQ.21
- new net DIO47: SERIAL_TO_DAQ.22
- new net DIO48/UART0-TX: SERIAL_TO_DAQ.23
- new net DIO49/UART0-RX: SERIAL_TO_DAQ.24
- new net DIO50: SERIAL_TO_DAQ.25
- new net DIO51: SERIAL_TO_DAQ.26
- new net DIO52/UART1-TX: SERIAL_TO_DAQ.27
- new net DIO53/UART1-RX: SERIAL_TO_DAQ.28
- new net DIO54/UART1-CTS: SERIAL_TO_DAQ.29
- new net DIO55/UART1-RTS: SERIAL_TO_DAQ.30
- new net DIO56/UART2-TX: SERIAL_TO_DAQ.31
- new net DIO57/UART2-RX: SERIAL_TO_DAQ.32
- new net DIO58/UART2-CTS: SERIAL_TO_DAQ.33
- new net DIO59/UART2-RTS: SERIAL_TO_DAQ.34
- new net DIO60: SERIAL_TO_DAQ.35
- new net DIO61: SERIAL_TO_DAQ.36
- new net DIO62: ANALOG_TO_DAQ.31
- new net DIO63: ANALOG_TO_DAQ.32
- new net DIO64: ANALOG_TO_DAQ.33
- new net DIO65: ANALOG_TO_DAQ.34
- new net DIO66: ANALOG_TO_DAQ.35
- new net DIO67: ANALOG_TO_DAQ.36
- new net DIO68: ANALOG_TO_DAQ.37
- new net DIO69: ANALOG_TO_DAQ.38
- new net MBUS-SCL: ANALOG_TO_DAQ.4
- new net MBUS-SCL-1: SERIAL_TO_DAQ.4
- new net MBUS-SDA: ANALOG_TO_DAQ.3
- new net MBUS-SDA-1: SERIAL_TO_DAQ.3
- new net V5D: SERIAL_TO_DAQ.5, SERIAL_TO_DAQ.6
- net +12V: no longer JP1.1, JP2.1
- net +24V: no longer C22.1, C23.1, R33.2, U$1.IN
- net +5V: now also ANALOG_TO_DAQ.5, ANALOG_TO_DAQ.6, POE_IB_5V.1, R30.2; no longer C19.1, D29.2, JP1.3, JP2.3, L2.2, R79.2
- net GND: now also AMBIENT2-2.S, CRYO5-2.S, POE_IB_5V.2; no longer C19.2, C22.2, C23.2, D28.A, R30.1, R34.1, R42.1, R43.1, U$1.GND
- net N$16: now also ANALOG_TO_DAQ.11; no longer C48.1, R79.1
- net N$32: now also CRYO5-1.S, R26.1; no longer JP4.2
- net N$34: now also AMBIENT2-1.S, R30.1, R40.2; no longer JP5.1, OPEN2-1.S, R52.1
Other:
- note added: "24V input, 12V output voltage regulator (for Pressure and Unallocated Sensors)"
- note added: "5V input from POE+ Input Board; up to 3A (for AD58344 & RTD Sensors)"
- note removed: "24V input, 12V output voltage regulator (for ADS8344 and RTD Sensors)"
- note removed: "24V input, 5V output voltage regulator (for ADS8344 and RTD Sensors)"
- moved on the sheet: C28, C29, D18, D2, R39, R40
