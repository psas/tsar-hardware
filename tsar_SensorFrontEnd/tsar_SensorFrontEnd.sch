File: tsar_SensorFrontEnd/tsar_SensorFrontEnd.sch (EAGLE design)
At the start: 218 parts, among them U1 ADS8344N, U2 ADS8344N

Commit message: SFE/AC changes
AC: began replacing nucleo with bare metal stm
SFE: replaced all passives with oresal parts
Parts:
- C1, C10, C11, C12, C13, C14, C16, C17, C18, C2, C20, C21, C24, C27, C28, C29, C3, C30, C31, C32, C33, C34, C35, C36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: device rcl:C-USC0603 -> oresat-rcl:C-USC0603K
- C25, C52, C53: device rcl:R-US_R1206 -> oresat-rcl:C-USC1206K
- C26, C45: device rcl:C-USC0805 -> oresat-rcl:C-USC0805K
- R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R27, R28, R29, R3, R31, R32, R39, R4, R40, R41, R44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: device rcl:R-US_R0603 -> oresat-rcl:R-US_0603-A-NOSILK
- R21, R22, R23, R24, R25, R26, R30, R35, R36, R69, R75: device marionette:R-US_0805-B -> oresat-rcl:R-US_0805-A-NOSILK
- R53, R77: device rcl:R-US_R0603 -> oresat-rcl:R-US_0805-A-NOSILK
- R76: device rcl:R-US_R1206 -> oresat-rcl:R-US_1206-A
Other:
- moved on the sheet: 12V., L3, R69, R75

Commit message: board corrections following test case.
issue #6 closed.
Parts:
- removed JP6: (no value), adafruit:PINHD-1X3
- removed R44: NP, oresat-rcl:R-US_0603-A-NOSILK
- R1, R10, R2, R3, R4, R5, R6, R7, R8, R9: device oresat-rcl:R-US_0603-A-NOSILK -> oresat-rcl:R-US_0805-A-NOSILK; DPN P150BYCT-ND -> A110464CT-ND; MFR Panasonic Electronic Components -> TE Connectivity Passive Product; MPN ERJ-PA3F1500V -> 4-2176091-1
- R75: DPN 2019-RK73H2ATTD2372FCT-ND -> 2019-RK73H2ATTD8201FCT-ND; MPN 2019-RK73H2ATTD8201FCT-ND -> RK73H2ATTD8201F
Connections:
- removed net N$28: JP6.3, OPEN3-2.S, R44.2
- removed net N$42: JP6.2, R41.2
- net GND: now also OPEN3-2.S; no longer R44.1
- net N$33: now also R41.2; no longer JP6.1

Commit message: POE, SFE changes
POE: added gnd vias and text info
SFE: moved to mar dxf outline. removed unallocated lines and added valve position sensor pinout. updated attributes. the board is currently unrouted.
Parts:
- removed AMBIENT, AMBIENT2, CRYO1, CRYO2, CRYO3, CRYO4, CRYO5, OPEN10, OPEN11, OPEN3, OPEN4, OPEN5, OPEN6, OPEN7, OPEN8, OPEN9, OPENHS1, OPENHS2, PIT2, PIT5, PIT6, PT1, PT2, PT3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: 22-23-2021, con-molex:22-23-2021
- removed JP3, UA_10_S, UA_10_V, UA_11_S, UA_11_V, UA_4_S, UA_4_V, UA_5_S, UA_5_V, UA_6_S, UA_6_V, UA_7_S, UA_7_V, UA_8_S, UA_8_V, UA_9_S, UA_9_V: (no value), adafruit:PINHD-1X3
- removed R48, R50, R55, R57, R59, R63, R64, R65, R66, R67, R68, R70, R71, R72, R73, R74: NP, oresat-rcl:R-US_0603-A-NOSILK
- removed R53: NP, oresat-rcl:R-US_0805-A-NOSILK
- added PT-F01, PT-F02, PT-F03, PT-F04, PT-L01, PT-L02, PT-L03, PT-L04, PT-M01, PT-M02, TT-F01, TT-F02, TT-L01, TT-L02, TT-L03, TT-L04, TT-L05: 22-23-2021, con-molex:22-23-2021
- added TO_VI: (no value), pinhead:PINHD-1X12
- U1, U2: DIS (none) -> Digi-Key; DPN (none) -> ADS8344N-ND; MFR (none) -> Texas Instruments; MPN (none) -> ADS8344N
Connections:
- removed net N$33: OPEN3-1.S, R41.2, R53.1
- removed net N$36: JP3.2, R53.2
- removed net N$55: R68.2, UA_6_V.2
- removed net N$57: R67.2, UA_5_V.2
- removed net N$58: R66.2, UA_4_V.2
- removed net N$59: OPEN4-2.S, R63.2, UA_4_S.3
- removed net N$60: OPEN5-2.S, R64.2, UA_5_S.3
- removed net N$61: OPEN6-2.S, R65.2, UA_6_S.3
- removed net N$62: OPEN6-1.S, R68.1, UA_6_S.1
- removed net N$63: OPEN5-1.S, R67.1, UA_5_S.1
- removed net N$64: OPEN4-1.S, R66.1, UA_4_S.1
- removed net N$65: OPEN7-2.S, R48.2, UA_7_S.3
- removed net N$66: OPEN7-1.S, R73.1, UA_7_S.1
- removed net N$67: R47.2, UA_7_S.2
- removed net N$68: R60.2, UA_4_S.2
- removed net N$69: R61.2, UA_5_S.2
- removed net N$70: R62.2, UA_6_S.2
- removed net N$71: OPEN8-2.S, R50.2, UA_8_S.3
- removed net N$72: OPEN8-1.S, R72.1, UA_8_S.1
- removed net N$73: R49.2, UA_8_S.2
- removed net N$74: OPEN9-2.S, R55.2, UA_9_S.3
- removed net N$75: OPEN9-1.S, R71.1, UA_9_S.1
- removed net N$76: R54.2, UA_9_S.2
- removed net N$77: OPEN10-2.S, R57.2, UA_10_S.3
- removed net N$78: OPEN10-1.S, R70.1, UA_10_S.1
- removed net N$79: R56.2, UA_10_S.2
- removed net N$80: OPEN11-2.S, R59.2, UA_11_S.3
- removed net N$81: OPEN11-1.S, R74.1, UA_11_S.1
- removed net N$82: R58.2, UA_11_S.2
- removed net N$87: R71.2, UA_9_V.2
- removed net N$88: R70.2, UA_10_V.2
- removed net N$93: R74.2, UA_11_V.2
- removed net N$94: R73.2, UA_7_V.2
- removed net N$95: R72.2, UA_8_V.2
- new net HES1: R56.2, TO_VI.1
- new net HES2: R54.2, TO_VI.2
- new net HES3: R49.2, TO_VI.3
- new net HES4: R47.2, TO_VI.4
- new net HES5: R58.2, TO_VI.5
- new net HES6: R60.2, TO_VI.6
- new net HES7: R61.2, TO_VI.7
- new net HES8: R62.2, TO_VI.8
- new net HES9: R41.2, TO_VI.9
- net +12V: now also PT-F01-1.S, PT-F02-1.S, PT-F03-1.S, PT-F04-1.S, PT-L01-1.S, PT-L02-1.S, PT-L03-1.S, PT-L04-1.S, PT-M01-1.S, PT-M02-1.S; no longer JP3.1, OPENHS1-1.S, OPENHS2-1.S, PIT2-1.S, PIT5-1.S, PIT6-1.S, PT1-1.S, PT2-1.S, PT3-1.S, PT4-1.S, PT5-1.S, UA_10_V.3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
- net +5V: no longer JP3.3, UA_10_V.1, UA_11_V.1, UA_4_V.1, UA_5_V.1, UA_6_V.1, UA_7_V.1, UA_8_V.1, UA_9_V.1
- net AMBIENT: now also R26.1, TT-L01-1.S; no longer AMBIENT-1.S, R25.1
- net CRYO1: now also TT-L05-1.S; no longer CRYO1-1.S
- net CRYO2: now also TT-L04-1.S; no longer CRYO2-1.S
- net CRYO3: now also TT-L03-1.S; no longer CRYO3-1.S
- net CRYO4: now also TT-L02-1.S; no longer CRYO4-1.S
- net GND: now also TT-F01-2.S, TT-F02-2.S, TT-L01-2.S, TT-L02-2.S, TT-L03-2.S, TT-L04-2.S, TT-L05-2.S; no longer AMBIENT-2.S, AMBIENT2-2.S, CRYO1-2.S, CRYO2-2.S, CRYO3-2.S, CRYO4-2.S, CRYO5-2.S, OPEN3-2.S, R48.1, R50.1, R55.1, R57.1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
- net N$1: now also PT-L02-2.S; no longer PT2-2.S
- net N$19: now also PT-F01-2.S; no longer OPENHS2-2.S
- net N$2: now also PT-F02-2.S; no longer OPENHS1-2.S
- net N$22: now also PT-L01-2.S; no longer PT1-2.S
- net N$29: now also PT-L03-2.S; no longer PT3-2.S
- net N$32: now also R25.1, TT-F02-1.S; no longer CRYO5-1.S, R26.1
- net N$34: now also TT-F01-1.S; no longer AMBIENT2-1.S
- net N$38: now also PT-L04-2.S; no longer PT4-2.S
- net N$40: now also PT-M01-2.S; no longer PT5-2.S
- net N$46: now also PT-F04-2.S; no longer PIT6-2.S
- net N$6: now also PT-M02-2.S; no longer PIT2-2.S
- net N$7: now also PT-F03-2.S; no longer PIT5-2.S
Other:
- note added: "Valve Position Sensors"
- note removed: "Bridge Center (Pin 2) to Pin 1 for Variable Current Bridge Center to Pin 3 for Variable Voltage"
- note removed: "Bridge Center Pin to Pin 1 For Variable Voltage Sensor Bridge Center Pin to Pin 3 for Variable Current Sensor"
- note removed: "Bridge Center Pin to Pin 3 for 12V power to sensor Bridge Center Pin to Pin 1 for 5V power to sensor"
- note removed: "Bridge R45 for Variable Current Sensors Pick R45 for Resistive (Variable Voltage) Sensor"
- note removed: "Bridge Resistor for Variable Current Sensor Set Resistor to Correct Divider Value for Resistive Variable Voltage Sensor"
- note removed: "Jump Pins to 5V or 12V as needed by sensor"
- note removed: "Unallocated"
- moved on the sheet: ANALOG_TO_DAQ, C1, C10, C11, C12, C13, C14, C16, C17, C18, C2, C20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

Commit message: SFE routes completed
Connections:
- new net N$3: ANALOG_TO_DAQ.5, ANALOG_TO_DAQ.6
- net +5V: no longer ANALOG_TO_DAQ.5, ANALOG_TO_DAQ.6
