File: tsar_SensorFrontEnd/tsar_SensorFrontEnd.sch (EAGLE design)
At the start: 215 parts

Commit message: thick routes on AC board. protections on SFE
Parts:
- removed H1, H2: #4-BARE_MOUNTING_HOLE/.300, mount:#4-BARE_MOUNTING_HOLE/.300
- added C43: 100nF, rcl:C-EUC0805
- added C44: 22uF, rcl:C-EUC0805
- added C45: 4.7uF, rcl:C-EUC0805
- added C46: 0.1uF, rcl:C-EUC0805
- added C47, C48, C49: 47pF, rcl:C-USC0603
- added D31: DFLS160, diode:DIODE-DO214AA
- added L3: 33uH, TSAR_Controller (2):CLF5030NIT-100M-D
- added R69: 113k, marionette:R-US_0805-B
- added R75: 8.2k, marionette:R-US_0805-B
- added R76: 500k, marionette:R-US_0805-B
- added R77: NP, marionette:R-US_0805-B
- added R78, R79, R80, R81, R82, R83: 0, rcl:R-US_R0603
- added U$2: MP2456GJ-P, TSAR_Controller (2):MP2456GJ-P
- C15: value 0.1uF -> 100nF
- C22, C26: DPN 1276-1244-1-ND -> 1276-1248-2-ND; MPN CL21A475KAQNNNE -> CL21A475KBQNNNE
- R33: value 10k -> 500k
- R37: DPN 2019-RN73R2ATTD1002F25CT-ND -> RHM10KADTR-ND; MFR KOA Speer Electronics, Inc. -> Rohm Semiconductor; MPN RN73R2ATTD1002F25 -> ESR03EZPF1002
Connections:
- new net FLY3: C43.2, D31.C, L3.1, U$2.SW
- new net N$11: C43.1, R81.2
- new net N$12: C47.2, R69.1, R75.2, U$2.FB
- new net N$13: R76.1, R77.2, U$2.EN
- new net N$14: C47.1, R80.1
- new net N$15: R81.1, U$2.BST
- new net N$16: C48.1, R79.1
- new net N$17: C15.1, R78.1
- new net N$18: C49.2, R35.1, R36.2, U$4.FB
- new net N$20: C49.1, R82.1
- net +12V: now also C45.1, C46.1, R76.2, U$2.IN
- net +3V3: now also R82.2
- net +5V: now also C44.1, L3.2, R69.2, R79.2, R80.2
- net GND: now also C44.2, C45.2, C46.2, D31.A, R75.1, R77.1, U$2.GND
- net N$3: now also R78.2; no longer C15.1
- net N$4: now also R83.1; no longer D30.1, U$4.BST
- net N$5: now also D30.1, R83.2, U$4.BST; no longer R35.1, R36.2, U$4.FB
- net N$9: now also C48.2
Other:
- moved on the sheet: C15, C19, C22, C23, C24, C25, C26, C27, D27, D28, D29, D30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

Commit message: bom, attributes, sizing, layout
updated BOMs, changed smds from 0805 to 0603, updated attributes, changed layout to reduce overall board size.
Parts:
- removed C44: 22uF, rcl:C-EUC0805
- removed JP10, JP7, JP8, JP9: (no value), adafruit:PINHD-1X3
- removed R45, R46: NP, marionette:R-US_0805-B
- added C50, C51: 1uF, rcl:C-USC0603
- added C52, C53: 10uF, rcl:C-USC0805
- C1, C10, C16, C17, C18, C2, C20, C21, C28, C29, C3, C30, C35, C36, C37, C38, C39, C4, C40, C41, C42, C5, C6, C7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: device rcl:C-EUC0805 -> rcl:C-USC0603; DPN 399-7139-1-ND -> 1276-1160-1-ND; MFR KEMET -> Samsung Electro-Mechanics; MPN C0805C121KDRACTU -> CL10C121JB8NNNC
- C11, C13, C14, C32, C33, C34: device rcl:C-EUC0805K -> rcl:C-USC0603; DPN 1276-2395-1-ND -> 1276-1860-1-ND; MPN CL21A105KACLNNC -> CL10A105KB8NNNC
- C12, C31: device rcl:C-EUC0805K -> rcl:C-USC0603; DPN 490-4789-1-ND -> 1276-CL10B104KB8NNNLTR-ND; MPN GCM21BR72A104KA37L -> CL10B104KB8NNNL
- C15, C23, C24, C27, C43, C46: device rcl:C-EUC0805 -> rcl:C-USC0603; DPN 490-4789-1-ND -> 1276-CL10B104KB8NNNLTR-ND; MFR Murata Electronics -> Samsung Electro-Mechanics; MPN GCM21BR72A104KA37L -> CL10B104KB8NNNL
- C19, C25: device rcl:C-EUC0805 -> rcl:C-USC0805; DPN 490-5523-1-ND -> 490-18664-2-ND; MPN GRM21BR61E106KA73L -> GRM21BR61H106ME43L
- C22, C26, C45: device rcl:C-EUC0805 -> rcl:C-USC0805
- C47, C48, C49: DIS (none) -> Digi-Key; DPN (none) -> 445-1277-1-ND; MFR (none) -> TDK Corporation; MPN (none) -> C1608C0G1H470J080AA
- L3: DPN 445-174699-1-ND -> 240-3161-2-ND; MFR TDK Corporation -> Laird-Signal Integrity Products; MPN CLF5030NIT-100M-D -> MGV0503330M-10
- R1, R2: value NP -> 150; device marionette:R-US_0805-B -> rcl:R-US_R0603; DIS (none) -> Digi-Key; DPN (none) -> P150BYCT-ND; MFR (none) -> Panasonic Electronic Components; MPN (none) -> ERJ-PA3F1500V
- R10, R3, R4, R5, R6, R7, R8, R9: device marionette:R-US_0805-B -> rcl:R-US_R0603; DPN RNCP0805FTD150RCT-ND -> P150BYCT-ND; MFR Stackpole Electronics Inc -> Panasonic Electronic Components; MPN RNCP0805FTD150R -> ERJ-PA3F1500V
- R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R27, R28, R29, R31, R32, R39, R40, R41, R47, R49, R54, R56, R58, R60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: device marionette:R-US_0805-B -> rcl:R-US_R0603; DPN 311-1.00KCRCT-ND -> P1.0KBYCT-ND; MFR Yageo -> Panasonic Electronic Components; MPN RC0805FR-071KL -> ERJ-PA3F1001V
- R26: DPN 2019-RK73H2ATTD1243FCT-ND -> 2019-RK73H2ATTD1243FTR-ND
- R30, R36: DPN 2019-RK73H2ATTD2372FCT-ND -> 2019-RK73H2ATTD2372FTR-ND
- R33, R76: device marionette:R-US_0805-B -> rcl:R-US_R1206; DPN 2019-RN73R2ATTD1002F25CT-ND -> BC4966TR-ND; MFR KOA Speer Electronics, Inc. -> Vishay Dale; MPN RN73R2ATTD1002F25 -> CRMA1206AF500KFKEF
- R34, R38, R42, R43, R44, R48, R50, R51, R52, R53, R55, R57, R59, R63, R64, R65, R66, R67, R68, R70, R71, R72, R73, R74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: device marionette:R-US_0805-B -> rcl:R-US_R0603
- R35: DPN 541-73.2KCCT-ND -> 2019-RK73H2ATTD7322FTR-ND; MFR Vishay Dale -> KOA Speer Electronics, Inc.; MPN CRCW080573K2FKEA -> RK73H2ATTD7322F
- R69: DPN 2019-RK73H2ATTD1243FCT-ND -> 2019-RK73H2ATTD1133FCT-ND; MPN RK73H2ATTD1243F -> RK73H2ATTD1133F
- R75: MPN RK73H2ATTD2372F -> 2019-RK73H2ATTD8201FCT-ND
- R78, R79, R80, R81, R82, R83: DIS (none) -> Digi-Key; DPN (none) -> 541-2779-2-ND; MFR (none) -> Vishay Dale; MPN (none) -> RCS06030000Z0EA
Connections:
- removed net N$43: JP7.2, R45.2
- removed net N$44: JP8.3, OPENHS2-1.S, R45.1
- removed net N$45: JP9.1, OPENHS1-1.S, R46.1
- removed net N$47: JP10.2, R46.2
- removed net N$48: JP9.3, OPENHS1-2.S, R2.2
- removed net N$49: JP8.1, OPENHS2-2.S, R1.2
- new net +24V: C22.1, C23.1, C26.1, C27.1, C45.1, C46.1, POE-1.S, POE_BYPASS.1, R33.2, R37.2, R76.2, U$1.IN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
- net +12V: now also C50.1, C51.1, C52.1, C53.1, L3.2, OPENHS1-1.S, OPENHS2-1.S, R69.2, R80.2; no longer C22.1, C23.1, C26.1, C27.1, C45.1, C46.1, JP10.3, JP7.1, POE-1.S, POE_BYPASS.1, R33.2, R37.2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
- net +5V: no longer C44.1, JP10.1, JP7.3, L3.2, R69.2, R80.2
- net GND: now also C50.2, C51.2, C52.2, C53.2; no longer C44.2
- net N$19: now also OPENHS2-2.S, R1.2; no longer JP8.2
- net N$2: now also OPENHS1-2.S, R2.2; no longer JP9.2
Other:
- note added: "+24V input from POE 24V @ < 3000mA"
- note added: "24V input, 12V output voltage regulator (for ADS8344 and RTD Sensors)"
- note added: "24V input, 3V3 output voltage regulator (for ADS8344 output logic level)"
- note added: "24V input, 5V output voltage regulator (for ADS8344 and RTD Sensors)"
- note added: "ALL CAPACITORS ARE 0805 10% X5R WITH WORKING VOLTAGE > 50V UNLESS OTHERWISE MARKED"
- note added: "ALL RESISTORS ARE 0603 1% UNLESS OTHERWISE MARKED"
- note removed: "+12V input from POE 12V @ < 1000mA"
- note removed: "12V input, 3V3 output voltage regulator (for ADS8344 output logic level)"
- note removed: "12V input, 5V output voltage regulator (for ADS8344 and RTD Sensors)"
- note removed: "ALL CAPACITORS ARE 0805 10% X5R WITH WORKING VOLTAGE > 25V UNLESS OTHERWISE MARKED"
- note removed: "ALL RESISTORS ARE 0805 1% UNLESS OTHERWISE MARKED"
- moved on the sheet: C1, C47, D8, L3, OPENHS1-1, OPENHS1-2, OPENHS2-1, OPENHS2-2, R69, R75, R80

Commit message: layout, attributes, bom.
Parts:
- added 12V., 3V3., 5V., POE.: (no value), led:LEDCHIP-LED0603
- added R45, R46, R84, R85: (no value), rcl:R-US_R0603
- C23, C46: value 0.1uF -> (none)
- C26: value 4.7uF -> (none)
- C39, C40, C41, C42: value 120pF -> (none)
- C50: value 1uF -> (none)
- C53: value 10uF -> (none)
- L1: value 10uH -> CLF5030NIT-100M-D
- R58, R60, R61, R62: value 1k -> (none)
- R59, R63, R64, R65: value NP -> (none)
- renumbered JP11 to UA_4_V, JP12 to UA_5_V, JP13 to UA_6_V, JP14 to UA_4_S, JP15 to UA_5_S, JP16 to UA_6_S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
Connections:
- new net N$30: 3V3..A, R84.1
- new net N$43: 5V..A, R46.1
- new net N$44: 12V..A, R45.2
- new net N$45: POE..A, R85.2
- net +12V: now also R45.1
- net +24V: now also R85.1
- net +3V3: now also R84.2
- net +5V: now also R46.2
- net GND: now also 12V..C, 3V3..C, 5V..C, POE..C

Commit message: replaces 4 caps with 1206 due to stock
Parts:
- 12V.: value (none) -> blue
- 3V3., 5V., POE.: value (none) -> red
- C19, C25, C52: device rcl:C-USC0805 -> rcl:R-US_R1206
- C23, C46: value (none) -> 0.1uF
- C26: value (none) -> 4.7uF
- C39, C40, C41, C42: value (none) -> 120pF
- C50: value (none) -> 1uF
- C53: value (none) -> 10uF; device rcl:C-USC0805 -> rcl:R-US_R1206
- R45, R85: value (none) -> 20k
- R46, R58, R60, R61, R62, R84: value (none) -> 1k
- R59, R63, R64, R65: value (none) -> NP
